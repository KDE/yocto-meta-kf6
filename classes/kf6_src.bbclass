# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

# Common source metadata for KDE Frameworks releases.
KF6_VERSION ?= "${@'.'.join(d.getVar('PV').split('.')[:2])}"

SRC_URI = "https://download.kde.org/stable/frameworks/${KF6_VERSION}/${BPN}-${PV}.tar.xz"
SRC_URI[sha256sum] = "${SRC_URI_SHA256SUM_${BPN}}"

SRC_URI_SHA256SUM_attica = "fa39cc74cd34ffd4beb906099a5f42e4180432b5839a75a4b251c0ae2fb01ab1"
SRC_URI_SHA256SUM_baloo = "d7746f5742d96f85c11b64a1aae8a6af1f20e55b815f81da8a4e6c3c5172a2d9"
SRC_URI_SHA256SUM_bluez-qt = "e728c968d633cfd5921dd5cf5b424a33f17a7682d1c780437e15710aa3ff2101"
SRC_URI_SHA256SUM_breeze-icons = "2188492d83ead80cae83cbb0db80cac0b55388ea2e3e02d436354b6ca2559d0c"
SRC_URI_SHA256SUM_extra-cmake-modules = "ffeb4951bf09b2b8ee17ef24a28b6de650c0db0f59ddffb9009b37cac63af348"
SRC_URI_SHA256SUM_frameworkintegration = "eb8d55bd04cb023ea0480cf82c396d63b4a14ae7e5f60963a00a0d58f47a8022"
SRC_URI_SHA256SUM_karchive = "123a268352ab63d548ba5e3c3e8fbf1d737025e4c5189821cf10e3328ab4de15"
SRC_URI_SHA256SUM_kauth = "e1a9b20a1b8718a0a0ead943e6ae999692fe7efe6b5bd513fdb5ba1849e4bdf0"
SRC_URI_SHA256SUM_kbookmarks = "5c4a8c1f8499f6ff1cdd035b56f6fe321244913b1894a8c6001c3acf082c5bd6"
SRC_URI_SHA256SUM_kcalendarcore = "d6a19c3ec0cdfc6979bfde08ce7c62db8c52dd9dff4a13e4da8978e00480dfeb"
SRC_URI_SHA256SUM_kcmutils = "cc7c01e948d7040e9e002ea5379ce8c05f2a85f28cdd4431aee106bdf0661c3d"
SRC_URI_SHA256SUM_kcodecs = "5051fe783803d94444a231c79635b96f1266594942b836f59ae8460497c788c5"
SRC_URI_SHA256SUM_kcolorscheme = "95a8a37817765f910c59b269a9958557505b99ff698fd6d220bcb166d5e302f5"
SRC_URI_SHA256SUM_kcompletion = "e4138d525eb9e27a9222d655e412c0de8b4bd7b34289d1c7ca5a808e20b53238"
SRC_URI_SHA256SUM_kconfig = "8c675c9d35a866fbf1b564354a589019b429cca949f7ba3ba0adb9f2fa15959c"
SRC_URI_SHA256SUM_kconfigwidgets = "c45ee1f4b2ede987efc8deac48710d87d9d37bb8355f0d7e130d557dfb2029a2"
SRC_URI_SHA256SUM_kcontacts = "386826b3886d6b32a4583e638493ccd3cfb37722faaf318742d70d6bf0e3f0a7"
SRC_URI_SHA256SUM_kcoreaddons = "e7f0825576dc44af0c7194538e48114aa240f8fd3402f27047771f009e161a7e"
SRC_URI_SHA256SUM_kcrash = "b1b952c500787e760c0fca3ce20c6ed8cf488ed106e0e72bc604509df84d8fd7"
SRC_URI_SHA256SUM_kdav = "a16c4cc1b21cdf2739e1ba20b77a5212b9daabc7e395259771dd077f5200f14b"
SRC_URI_SHA256SUM_kdbusaddons = "b872463ff1874beeff86cf951e510488e959d595ca3d2839fb8e9639fbffb0e2"
SRC_URI_SHA256SUM_kdeclarative = "7692ccdffd55826976e916927b59aeb2d24a77b16af967fb265e9fe0cde387fa"
SRC_URI_SHA256SUM_kded = "030cc827c37b490a2181e120cd831b73c9a7683a87cf55d0d5b334059f78c590"
SRC_URI_SHA256SUM_kdesu = "09ad4bf5fe7abae40884f8b645b22948cd00f418c7d643a0b5d505a02ef6f634"
SRC_URI_SHA256SUM_kdnssd = "865175616c5169d25f0783798e0a7918a418180c33828e461c1608e6121d3634"
SRC_URI_SHA256SUM_kdoctools = "2c5866257edda20f33c35f64a8bcab08de3dddb4e751bbbc2e09e941df979918"
SRC_URI_SHA256SUM_kfilemetadata = "78b3516ab3038fec122f86c1370f4c7d8857ddea9e907263242affae1dd1f738"
SRC_URI_SHA256SUM_kglobalaccel = "81f9842f13db8e2d4384c0f02650cd076441d2fba9540820901fffe1d2f4897f"
SRC_URI_SHA256SUM_kguiaddons = "38850963cb91978d08e781d81b147c7b66f78f4204ad820631e42ab1ef5ef76b"
SRC_URI_SHA256SUM_kholidays = "13c345422f802bd157aaea18b2ccb5270eb5e3de44915bcce70f1a4234e1497b"
SRC_URI_SHA256SUM_ki18n = "7fbac8bc88f5cb1af00f6a667381c4bcebba6f417dc6a3c7eef8bded6c9161de"
SRC_URI_SHA256SUM_kiconthemes = "f68f0d810a53ec589fbbc0b05d3754e2bd26e0b7c3ceb3938698b08702ae10d5"
SRC_URI_SHA256SUM_kidletime = "64e83d46a15b444017c6341e479e229bbd6cbb8320ef1359773737cee89dd7ca"
SRC_URI_SHA256SUM_kimageformats = "dfa0e9b16a288a8f94233afcbaffc87c1c5ddc037aca643943aab5a67685f26b"
SRC_URI_SHA256SUM_kio = "bf71b2227016df6566665cead6cb468726d7cc708059e812daee7ea54f405378"
SRC_URI_SHA256SUM_kirigami = "da7f3b733557b19975bb6b122e05d2f4d9214a70a81e2bb6e71c65761a3c6b43"
SRC_URI_SHA256SUM_kitemmodels = "ab78119a00b84eac65ffc986df30fbf9b1b8d00635e8fc626372e84580d158ca"
SRC_URI_SHA256SUM_kitemviews = "b57f38d6fd184a4b260d0b35d76f6c0fb96bdd80475e3ca7d4151023730e5d3d"
SRC_URI_SHA256SUM_kjobwidgets = "756bdc0a1c89a8e732ea7299bd325c38b81604da76b4cf361ccfc8b40a6e781e"
SRC_URI_SHA256SUM_knewstuff = "8c31ef25a7d7389473d12245ae564ad888467b8ef910ac212e16e9334540cd08"
SRC_URI_SHA256SUM_knotifications = "0884add69f26a455cb8b6327bf89dc7ad3a0e4397c43c202fcf7ff73204ec695"
SRC_URI_SHA256SUM_knotifyconfig = "8dc37406d8f13193216201752ece968cbd38da5a76780ad78575d11b47b440ea"
SRC_URI_SHA256SUM_kpackage = "bd465c0f1c11ec4c6767c985ebd144cc1efd6b6f249e7d19bf2cc04b956a663e"
SRC_URI_SHA256SUM_kparts = "f0d6346e3127d1e44506733113be467d8b50cb82731d300a57990dd09baaedf1"
SRC_URI_SHA256SUM_kpeople = "8bece583572330449dfa735b589b1df276759dbbb3a1f3a4d134c5677e2bf558"
SRC_URI_SHA256SUM_kplotting = "9fbd4775c9b1f56a24d90ee47cd0ad57c816fbbf60e3aaeba6e2b631f7b3fc9b"
SRC_URI_SHA256SUM_kpty = "eb4deb424bdf20328dac0a12fdaab715dbf800e1cd08a4188cc2d3075543709f"
SRC_URI_SHA256SUM_kquickcharts = "146598a1e107e8480631b3001fd39d264e81dd5af6a315dec71524465d099244"
SRC_URI_SHA256SUM_krunner = "a2cf0c9ae296868250b15b8446d657063a95c70d9d182b007814fb59efa50419"
SRC_URI_SHA256SUM_kservice = "04fa9f824e50c25b6ad7e29262c6566e0ce11edefb9fede317399a88501e9f74"
SRC_URI_SHA256SUM_kstatusnotifieritem = "7a6397f08b15a7d50e407c193f1774b548994f6f9d12327dfbb674270adfc9af"
SRC_URI_SHA256SUM_ksvg = "9c05166e289d39603696944edfbc3b50a1aadcd19e5b602002013c6149a44129"
SRC_URI_SHA256SUM_ktexteditor = "77e815edcdf572397f5eb750d7232b366f6cc6274bb34246ab88f2f2179733b4"
SRC_URI_SHA256SUM_ktexttemplate = "4e9f7583b3dcb37980b99fb2ac2de9e95af8b14fe9a166752bcb83c66ce26e25"
SRC_URI_SHA256SUM_ktextwidgets = "adb35bb19fb27e89b999645f8f9d650d1de3e8ed9bb686120705fdcd1cb0f3de"
SRC_URI_SHA256SUM_kunitconversion = "369ef042de797ea647994c524cc43915b514850026cfddb4b24bc78bdfc3dcc8"
SRC_URI_SHA256SUM_kuserfeedback = "4ce9fd672bed20ce646cd175522d207e0fe753fe42c5cf773c087927c0f30fe3"
SRC_URI_SHA256SUM_kwallet = "6fe7c8f4c556db4861f0046dfe179c31e7891fb6ecdcfa33692d252bf23d3b11"
SRC_URI_SHA256SUM_kwidgetsaddons = "8a9f9cde4427ffec37a0501d337aadae3de39736674f571ff8a13d17d1e6c938"
SRC_URI_SHA256SUM_kwindowsystem = "b51448a7669efa18190ab7fa8d6f5e0f77d8f9879cf457dadb4629b245a02434"
SRC_URI_SHA256SUM_kxmlgui = "02d97c24ec0bc102c299f3429056b45025e24d59ec31464317a3062cc1fc2021"
SRC_URI_SHA256SUM_modemmanager-qt = "1f1c3ef493445a3f9215462dd86d25e2e4355ffbce9a70016288be04c537b91b"
SRC_URI_SHA256SUM_networkmanager-qt = "c3874938892c43ae8d486cd7b71e586f3ad368518cbf80034dcbf97516976756"
SRC_URI_SHA256SUM_prison = "9f4a8fa5732e45142c9ba2e35a38904d44193efc050e1ca20a414445c3a98b34"
SRC_URI_SHA256SUM_purpose = "773abfa91f50ce10419373fdb4e7e0b2be009e739f8de2f3450d3ef169b6a23e"
SRC_URI_SHA256SUM_qqc2-desktop-style = "c09070e57a196baab50e62aac5e17051666a898d95ac29d8853c6634a02ab9d1"
SRC_URI_SHA256SUM_solid = "8177fa8f139b855856e171426c5f2adb96d727e62e6ec536675da11aa157b33e"
SRC_URI_SHA256SUM_sonnet = "510521f1404914943b3141e0b111f2330bbeefdf40405f93c0cf7b84a8c1c589"
SRC_URI_SHA256SUM_syndication = "953f5935b1a0ba7c2c70cc213c0144d9c73855c802a1525be6c086543428f957"
SRC_URI_SHA256SUM_syntax-highlighting = "8aeee428e82ac96aad01bbd423518705d214e0f3a5ac1fd64389565d08e5d501"
SRC_URI_SHA256SUM_threadweaver = "f74ca31f5559f55870496df5372da09dfb409e197cc6e0f660979b98cd611444"
