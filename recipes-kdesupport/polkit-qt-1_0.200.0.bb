# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "aa1c6c414ec021fd32e30492c00bb13347e228db"
