# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
# NOTE: this is an arbitrary hash chosen to provide all
# dependencies of kwin at time of bumping
SRCREV = "e5ea68d0acb2f1264facb5bfdcd548d9aa0d1a25"
PR = "2"
