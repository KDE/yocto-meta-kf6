# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/oxygen-icons/oxygen-icons-6.0.0.tar.xz"
SRC_URI[sha256sum] = "28ec182875dcc15d9278f45ced11026aa392476f1f454871b9e2c837008e5774"
