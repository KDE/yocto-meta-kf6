# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI[sha256sum] = "338479dc451e4b94b3ca5b578def741dcf82f5c626a2807d36235be2dce7c9a5"
PR = "1"
