# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-wayland-protocols/plasma-wayland-protocols-${PV}.tar.xz"
SRC_URI[sha256sum] = "1a4385ecfc79f7589f07381cab11c3ff51f6e2fa4b73b78600d6ad096394bf81"
