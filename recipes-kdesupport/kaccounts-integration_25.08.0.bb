# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/kaccounts-integration-${PV}.tar.xz"
SRC_URI[sha256sum] = "7147947e4a236760ced2e65f9e4b7daffdad3e4e865a142f491a69fbaad5a6ea"
