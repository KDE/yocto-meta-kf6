# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "a2c137fe24e5fff389c359d8fde9155fbf45fac2"
