require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/libkexiv2-${PV}.tar.xz"
SRC_URI[sha256sum] = "123a3298897116605c436b4abe885cdfac77f375639d4881f8048ec0c636b736"
