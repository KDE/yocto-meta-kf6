# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/${BPN}/${BPN}-1.11.1.tar.xz"
SRC_URI[sha256sum] = "451aa890431cee5066fa93bf8c03640a18b5595621a18a35b1f777afd50186cd"

