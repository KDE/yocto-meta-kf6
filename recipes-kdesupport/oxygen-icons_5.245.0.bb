# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/oxygen-icons/oxygen-icons-5.245.0.tar.xz"
SRC_URI[sha256sum] = "b082a1a9a6d06cdeee2863555951609e95dd499f133035d04719a16f8500497f"
