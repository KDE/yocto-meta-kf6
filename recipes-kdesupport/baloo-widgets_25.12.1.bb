# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/${PV}/src/baloo-widgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "665a95086f2913054d5a660494e57de30f877cfe48d60f224b21c31b1ebe3069"
