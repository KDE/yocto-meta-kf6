# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "99a83b3a6ac514d7f850dda7fa24cddb5120c7e2"
