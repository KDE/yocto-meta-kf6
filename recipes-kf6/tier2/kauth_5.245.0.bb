# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kauth-5.245.0.tar.xz"
SRC_URI[sha256sum] = "e7cd61bd277368ac3bfc173dec5006d2854dc4173c1ee42412581faf328efa50"

