# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kpackage-6.8.0.tar.xz"
SRC_URI[sha256sum] = "d32e6f6148d9cd93f321a652cfa4d33fdf2349af1019641244e284e1d2c0d2b6"

