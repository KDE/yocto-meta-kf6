# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kstatusnotifieritem-6.2.0.tar.xz"
SRC_URI[sha256sum] = "04b9fc0905b614afc8e0afcf5451018d2a126f165221b6db20e4171be2fb1fcf"

