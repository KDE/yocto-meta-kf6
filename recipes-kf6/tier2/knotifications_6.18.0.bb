# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/knotifications-6.18.0.tar.xz"
SRC_URI[sha256sum] = "593cb00c9e04018477ba146031f6d46f4079c637c6a46630566712d842b9f3a8"

