# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kpty-6.3.0.tar.xz"
SRC_URI[sha256sum] = "63a49b39984ac18c79700cad4f8f83cbad2d006801366dc6b10429a6e00da0a6"

