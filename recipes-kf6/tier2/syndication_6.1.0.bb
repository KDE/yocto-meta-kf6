# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/syndication-6.1.0.tar.xz"
SRC_URI[sha256sum] = "09d5394a2e3024c1188be7b690347b79fc2141a6d1b833bc5b494bdcc32f9683"

