# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kcontacts-5.246.0.tar.xz"
SRC_URI[sha256sum] = "aa3d940c9c42941989543abe5623059b1346ca9cb0f46b387e2f9caa1d83911e"

