# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kpeople-5.249.0.tar.xz"
SRC_URI[sha256sum] = "212bca84fe98dfc9fedebd9f4073f66b4ea9946a9d7c29c69b7f15aa7f69c683"

