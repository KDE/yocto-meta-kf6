# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/knotifications-6.1.0.tar.xz"
SRC_URI[sha256sum] = "02f36f4bc1d2d1094e1b0203a34e037cec78303c6aad9d69f9ac8c7388acfcab"

