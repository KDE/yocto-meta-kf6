# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kimageformats-6.8.0.tar.xz"
SRC_URI[sha256sum] = "d9f262641cc47e5f2dd1bdd56ee92e379ab4cb34d460dfc884fd991250d7b417"

