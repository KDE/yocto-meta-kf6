# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kauth-6.13.0.tar.xz"
SRC_URI[sha256sum] = "a33bf07828d88cf499c8bfe717f02f7e289dcf4f58b8f3aae9e2f95615a8d8d6"

