# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kimageformats-6.3.0.tar.xz"
SRC_URI[sha256sum] = "0ed40771bd35ed53af7c4a5216111bef282275b2eb384ae0076c917db20c1210"

