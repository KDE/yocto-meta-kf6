# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kfilemetadata-6.6.0.tar.xz"
SRC_URI[sha256sum] = "218ccbc926e1e26765f7213b8aace7ebdaa785464efad2bb60f8e648362cfea0"

