# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kunitconversion-6.7.0.tar.xz"
SRC_URI[sha256sum] = "b303601c623cd66edb66a66fd72e957415b8dd33e70305be8136fa6b43b1a40a"

