# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kcontacts-5.249.0.tar.xz"
SRC_URI[sha256sum] = "0df5952965fa37257a341a45bdf7c661c19580e73050c3a20760ca2b36b3d02e"

