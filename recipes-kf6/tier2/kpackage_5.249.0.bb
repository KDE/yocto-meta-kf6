# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kpackage-5.249.0.tar.xz"
SRC_URI[sha256sum] = "28b666cd2ac047444dd4bae56b9edcc77c779bc14ec9b2aa704ea6df47141234"

