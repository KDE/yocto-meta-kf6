# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kjobwidgets-5.246.0.tar.xz"
SRC_URI[sha256sum] = "d63be3341abae3700494d3870a499119b92ca1b81b6cab71e7d489dd718ae2fb"

