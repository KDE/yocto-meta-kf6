# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/knotifications-5.245.0.tar.xz"
SRC_URI[sha256sum] = "995d77c36f443079d5de65f2ff1a73e0e83da554f011f815a99ade2f67fa4f74"

