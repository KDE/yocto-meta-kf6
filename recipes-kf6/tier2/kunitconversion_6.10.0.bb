# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kunitconversion-6.10.0.tar.xz"
SRC_URI[sha256sum] = "23c59904d48049deb8f1de8aa56e7b0c10a9fc82808f36a32f4f446433869dbf"

