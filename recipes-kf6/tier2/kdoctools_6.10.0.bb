# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kdoctools-6.10.0.tar.xz"
SRC_URI[sha256sum] = "03fa98e1213235ee4d4839d16e3edb22ee56849b9ab03d140639cf9facb6b038"

