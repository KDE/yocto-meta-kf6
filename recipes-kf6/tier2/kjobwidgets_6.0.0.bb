# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kjobwidgets-6.0.0.tar.xz"
SRC_URI[sha256sum] = "5239d0d47af8118c962b59816fceeebbff930a43ab7923438982ac08dbcb84be"

