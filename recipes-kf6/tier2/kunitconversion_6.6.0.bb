# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kunitconversion-6.6.0.tar.xz"
SRC_URI[sha256sum] = "a874f093a3e64f08d1d37e1142e17d78a112b613ece5cfa1f747dd1d26789f91"

