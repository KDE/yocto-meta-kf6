# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kcrash-5.245.0.tar.xz"
SRC_URI[sha256sum] = "6dd54a910a84dcaf52772a9a9f22d61d527bfc9fe3f60678cc13a5ae6c66278b"

