# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kauth-5.246.0.tar.xz"
SRC_URI[sha256sum] = "ca98341171240b935ee6eeafc98326924a770cf3a584ef6440e149de7a594712"

