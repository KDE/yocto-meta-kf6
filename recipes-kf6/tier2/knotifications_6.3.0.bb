# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/knotifications-6.3.0.tar.xz"
SRC_URI[sha256sum] = "cced3c1a3795fedc90dc628c6b3cfff06d194eccfdca27b05938f5e941cc7877"

