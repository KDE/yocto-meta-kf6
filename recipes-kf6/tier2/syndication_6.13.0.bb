# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/syndication-6.13.0.tar.xz"
SRC_URI[sha256sum] = "1fe07a581705659753f995a7ee09977bf528b020a65978349b9722862da08fb7"

