# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/ksvg-5.246.0.tar.xz"
SRC_URI[sha256sum] = "b781060160f6ebf25725044053ca60192a5303438f19100939a89c03c1366aec"

