# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/ksvg-5.245.0.tar.xz"
SRC_URI[sha256sum] = "fc5fd0420638afdfe37e5cc2e4b2942b82cfd6808990b12e6056913ad39de391"

