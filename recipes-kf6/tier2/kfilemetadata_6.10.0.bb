# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kfilemetadata-6.10.0.tar.xz"
SRC_URI[sha256sum] = "100b48770a16b8e12dd3ec4075bdd3b8333e7962d2fc7492cd077dcc03e3c355"

