# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kcolorscheme-6.3.0.tar.xz"
SRC_URI[sha256sum] = "311730bdcf81009f5a79694f135a93040a4a83a66cb942d9617fcd6976049035"

