# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kstatusnotifieritem-6.18.0.tar.xz"
SRC_URI[sha256sum] = "d78aa20e1858f700478eecedb49714160d5e04b4a0d177bca4355aa1a0f7d730"

