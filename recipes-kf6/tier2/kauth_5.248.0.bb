# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kauth-5.248.0.tar.xz"
SRC_URI[sha256sum] = "2fea717f9e68b65564d71499cbc94614852abbcacde7505df392ce2c0b239dbe"

