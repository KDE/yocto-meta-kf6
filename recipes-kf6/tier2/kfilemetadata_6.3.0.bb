# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kfilemetadata-6.3.0.tar.xz"
SRC_URI[sha256sum] = "bd88e378861a03ada99c69841a81fceefd3dd220145007fbfe9113270b7d6088"

