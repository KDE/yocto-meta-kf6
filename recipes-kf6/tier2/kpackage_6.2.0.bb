# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kpackage-6.2.0.tar.xz"
SRC_URI[sha256sum] = "78c8466d7201f2aa6809d98588242aef6314be4a47155617c529c6a0549f395d"

