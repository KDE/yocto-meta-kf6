# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/syndication-6.6.0.tar.xz"
SRC_URI[sha256sum] = "627e4b310b8721e8b426ec5492f4036a7756d98933d318738352bfdd0a78a0d0"

