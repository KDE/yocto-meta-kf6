# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kunitconversion-5.248.0.tar.xz"
SRC_URI[sha256sum] = "205a81b4d25213ff6203bd06e73d8d34df115cc406c884bc6d4f6193a19f08a2"

