# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kauth-6.11.0.tar.xz"
SRC_URI[sha256sum] = "479660eabe97198c31f228a18271bc739b234943c68e95383c361a835131179b"

