# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kjobwidgets-6.4.0.tar.xz"
SRC_URI[sha256sum] = "22621a52cc69532a5495c7e8549d26af1ddd3b8532e9aa0d3c108950114dd565"

