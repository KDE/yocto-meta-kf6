# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kcontacts-6.10.0.tar.xz"
SRC_URI[sha256sum] = "b622ad011925584fb82cf0bfea713fddd4101c47ab6c23efb5fb878f1a69b46d"

