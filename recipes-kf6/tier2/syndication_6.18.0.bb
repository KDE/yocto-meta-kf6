# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/syndication-6.18.0.tar.xz"
SRC_URI[sha256sum] = "a02f76f8a942285f8a64233fb09f64d28f51eef9e96f4b5dd7d13d4c83933b94"

