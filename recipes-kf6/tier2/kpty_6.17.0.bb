# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kpty-6.17.0.tar.xz"
SRC_URI[sha256sum] = "96a71687a8de0becc34a8157572d2440ba8d4b976fd5d0813331dfd86b92aabb"

