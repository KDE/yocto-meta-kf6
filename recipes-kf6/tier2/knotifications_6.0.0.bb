# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/knotifications-6.0.0.tar.xz"
SRC_URI[sha256sum] = "35fed813fc594bbe808bc01b511b2d1eff9023977b7981137f3fec81984713e8"

