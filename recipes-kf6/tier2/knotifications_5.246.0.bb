# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/knotifications-5.246.0.tar.xz"
SRC_URI[sha256sum] = "dbbff23772e7acc565f0653baf3aedef31d8c3dffdfc07c89e7cf046d1f1bf36"

