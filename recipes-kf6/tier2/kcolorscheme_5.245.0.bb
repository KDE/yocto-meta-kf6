# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kcolorscheme-5.245.0.tar.xz"
SRC_URI[sha256sum] = "f987e02735daf3255213a171ece023bca1bca4923940ca9ec2171d483d48e41d"

