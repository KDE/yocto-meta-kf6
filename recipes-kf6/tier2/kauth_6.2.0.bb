# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kauth-6.2.0.tar.xz"
SRC_URI[sha256sum] = "3511d9d857c0f6962b005b381ec5e2fef9ded59244da14e31dd0673e05a69b0a"

