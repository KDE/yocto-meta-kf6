# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kcontacts-6.0.0.tar.xz"
SRC_URI[sha256sum] = "179c6748e555c5c028b02a4b9b165ede13a09cf5eaf0ea012366c9727d230ec4"

