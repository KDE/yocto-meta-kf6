# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kfilemetadata-6.4.0.tar.xz"
SRC_URI[sha256sum] = "45ff433054be4c5ef14a2aa842373c0679d632aacfdb78dfba989f7388c4c5ed"

