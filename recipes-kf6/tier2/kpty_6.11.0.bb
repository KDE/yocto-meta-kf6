# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kpty-6.11.0.tar.xz"
SRC_URI[sha256sum] = "f1d985bf0a14061a764c7c01bcb6cf284a59ad82de13e72cfd1bd268819eebc2"

