# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kcrash-5.249.0.tar.xz"
SRC_URI[sha256sum] = "79e938de42a5c1f478a19025f14605d4fcf764d1b866f6eb35717473bf50b9a4"

