# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kcrash-6.3.0.tar.xz"
SRC_URI[sha256sum] = "65c67a0fe9b8da27d0efe8a44e16a348e7f602b29511062f263b555ebea48f41"

