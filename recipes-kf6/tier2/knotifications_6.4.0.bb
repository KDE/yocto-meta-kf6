# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/knotifications-6.4.0.tar.xz"
SRC_URI[sha256sum] = "77e9b680066dc49c8d5e23ac6291fbba05328dda327d5c34ca3141e1ffeb25dc"

