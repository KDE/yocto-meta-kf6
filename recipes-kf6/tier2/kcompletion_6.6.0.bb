# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kcompletion-6.6.0.tar.xz"
SRC_URI[sha256sum] = "b80659b31fad437d19ec9486405d49f8db0cea709629e3b4ff0eb292ccf10b43"

