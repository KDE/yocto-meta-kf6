# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/ksvg-5.248.0.tar.xz"
SRC_URI[sha256sum] = "d42e7a8cdb4d26c440cc2477b903829affaf91ead23e34f3a70e9901a2893202"

