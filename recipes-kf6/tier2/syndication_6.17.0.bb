# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/syndication-6.17.0.tar.xz"
SRC_URI[sha256sum] = "d5a714b09ef6a50b67f55d58f8c6eefa1bba552527ded1145848b5466330ea93"

