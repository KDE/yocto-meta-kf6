# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kcolorscheme-6.8.0.tar.xz"
SRC_URI[sha256sum] = "2fda0768546919d427e34a9049bf5c5e8fe61a1d6b7e76df49bb42e22c1234dd"

