# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kpty-5.249.0.tar.xz"
SRC_URI[sha256sum] = "c93ac33b24190aa68c5a1a78995bd17e49d79e532c072a7a66afa07e1a71e7c3"

