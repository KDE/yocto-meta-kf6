# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/knotifications-6.17.0.tar.xz"
SRC_URI[sha256sum] = "b7801c546935e6082a72d4c7dd0387407b6a1905ab88de9bddaf369a8eca4141"

