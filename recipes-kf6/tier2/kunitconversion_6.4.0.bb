# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kunitconversion-6.4.0.tar.xz"
SRC_URI[sha256sum] = "30e969467cb6f20c97e263e5381371ead458517758128022141d52272a660474"

