# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kdoctools-5.248.0.tar.xz"
SRC_URI[sha256sum] = "f3d64f9bebfe8a380cf9b3621e831e965607e3ede92f847a8c36bdcd2b2a0dc3"

