# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kcolorscheme-5.246.0.tar.xz"
SRC_URI[sha256sum] = "4d3b62cad08e2b390d7f225833dd66ef817258264678d38a68e660204bd4cd78"

