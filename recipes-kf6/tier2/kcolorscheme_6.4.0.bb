# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kcolorscheme-6.4.0.tar.xz"
SRC_URI[sha256sum] = "5c74af476b36fc99b246d17fa30f8c9b9480f79277fa077908e75a8fc171828c"

