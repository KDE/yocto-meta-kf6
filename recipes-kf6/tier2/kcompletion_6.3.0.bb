# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kcompletion-6.3.0.tar.xz"
SRC_URI[sha256sum] = "3f027ac6bd285d040a5038c31b10e306bd2cb099d396e88536cd149e88ee712e"

