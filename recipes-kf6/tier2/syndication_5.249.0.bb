# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/syndication-5.249.0.tar.xz"
SRC_URI[sha256sum] = "5865da63a148e6e5e67c3db6907ffb2e31d8025ffa5ff34d1e6dc81a0f6ae16d"

