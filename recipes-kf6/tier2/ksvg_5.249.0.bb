# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/ksvg-5.249.0.tar.xz"
SRC_URI[sha256sum] = "60688d297534321fdb97caabce5aabafc2d693dcddf98ba4a3708e9d3a2a1a3d"

