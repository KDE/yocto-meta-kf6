# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kcontacts-6.4.0.tar.xz"
SRC_URI[sha256sum] = "b9b72d3bd1a64c0016b7122e79e657358226d239faf31699d6700d95e52bd59d"

