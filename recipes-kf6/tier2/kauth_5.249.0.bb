# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kauth-5.249.0.tar.xz"
SRC_URI[sha256sum] = "2833c86dd69756359210ae9343829431b8d563fd6eebdeb44fe2aebb46de4004"

