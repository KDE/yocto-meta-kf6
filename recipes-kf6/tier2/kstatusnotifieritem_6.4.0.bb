# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kstatusnotifieritem-6.4.0.tar.xz"
SRC_URI[sha256sum] = "32790111741482844ae1901c37db568346efc2ae68f712cecc6b9a5c1cba81b9"

