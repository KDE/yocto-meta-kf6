# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kdoctools-5.246.0.tar.xz"
SRC_URI[sha256sum] = "179b43429007da239d35ecfb880f7030c755124737bac45d073e7a55007641a9"

