# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kpackage-6.18.0.tar.xz"
SRC_URI[sha256sum] = "1bc2e43bf2239dc20e836b70877631e103057fb14a9467290c76fa45ff02870e"

