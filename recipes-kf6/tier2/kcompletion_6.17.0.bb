# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kcompletion-6.17.0.tar.xz"
SRC_URI[sha256sum] = "f22e4c6facec812bde4ab8d56a05b38a243dd9362c8deb4f1367efb1b6e64663"

