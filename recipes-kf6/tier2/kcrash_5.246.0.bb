# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kcrash-5.246.0.tar.xz"
SRC_URI[sha256sum] = "3649cc43b94fc52ae97a715b445ba70d6c42f9839b2ff9ac05aef944678c27e5"

