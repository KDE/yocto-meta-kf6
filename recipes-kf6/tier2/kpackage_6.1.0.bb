# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kpackage-6.1.0.tar.xz"
SRC_URI[sha256sum] = "ed75912b416580a4f9acdbedee31e590b197e157cda1dea13ad28751116b52af"

