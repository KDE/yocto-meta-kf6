# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kimageformats-6.10.0.tar.xz"
SRC_URI[sha256sum] = "e16f32ee64393199a283942f6fe7b6f77b3746034f90e4244689c28faab1f9d3"

