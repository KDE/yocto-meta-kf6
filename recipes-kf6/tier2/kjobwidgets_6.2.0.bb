# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kjobwidgets-6.2.0.tar.xz"
SRC_URI[sha256sum] = "2fb7602f2bba818bcfffe1ad1310d7900889e10e53e384b874295fb3593fb3a1"

