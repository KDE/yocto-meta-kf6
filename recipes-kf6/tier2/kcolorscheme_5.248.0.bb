# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kcolorscheme-5.248.0.tar.xz"
SRC_URI[sha256sum] = "780e6dfa244c7a233b647be6aa1d698bdc10824de10afe5e28beda8dae50eada"

