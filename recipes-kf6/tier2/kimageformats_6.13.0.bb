# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kimageformats-6.13.0.tar.xz"
SRC_URI[sha256sum] = "8cace92dc49ce24ad865b31d1bfb2eab2d7cf550542660f9d2a16dbe9b47f34e"

