# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kstatusnotifieritem-5.246.0.tar.xz"
SRC_URI[sha256sum] = "14adc191912ea6e73b33d13323383d41cd98cc6eb5d1905d982b979b81780f29"

