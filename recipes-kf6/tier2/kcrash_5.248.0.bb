# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kcrash-5.248.0.tar.xz"
SRC_URI[sha256sum] = "d28c1901de6fb6538b7b17d26600b0eb4d920abe0ec9b3a252b7095c50fc8858"

