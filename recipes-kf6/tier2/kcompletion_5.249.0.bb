# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kcompletion-5.249.0.tar.xz"
SRC_URI[sha256sum] = "b4dee671f65f8b2739e7f83c716144320ec287ed4c344a4d1050253022c2a78e"

