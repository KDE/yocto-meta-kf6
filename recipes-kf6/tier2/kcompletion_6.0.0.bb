# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kcompletion-6.0.0.tar.xz"
SRC_URI[sha256sum] = "f6434014e7979b6545906d1ff7a2920cfab65641369921e69f00a818b8eee559"

