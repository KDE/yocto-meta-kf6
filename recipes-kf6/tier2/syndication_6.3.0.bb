# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/syndication-6.3.0.tar.xz"
SRC_URI[sha256sum] = "cdf057c09be35e39809040072a67b8526ee612b6d8761f96f613b350d979c8d4"

