# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kauth-6.1.0.tar.xz"
SRC_URI[sha256sum] = "47e7804020805098cc9ab370b6c539991bb028041faaf5a619ab7cb2b992f08b"

