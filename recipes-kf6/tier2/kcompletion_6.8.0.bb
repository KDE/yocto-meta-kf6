# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kcompletion-6.8.0.tar.xz"
SRC_URI[sha256sum] = "8a915f42a49e021c8729b425a79906833490c9baa1b24af01cd4fc825b58c461"

