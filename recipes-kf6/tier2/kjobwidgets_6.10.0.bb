# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kjobwidgets-6.10.0.tar.xz"
SRC_URI[sha256sum] = "ee3ff5d21c8484959d0af1976a7c1bab01f4368414df2ebb2cb8540b3c28691b"

