# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kcompletion-6.1.0.tar.xz"
SRC_URI[sha256sum] = "e1e0bebe1edd88bea08bb0f47846d23624e34486df9c3a3380697fc4118449c8"

