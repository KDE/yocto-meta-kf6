# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/knotifications-5.248.0.tar.xz"
SRC_URI[sha256sum] = "c276832f8e2528a17d3aaeca2a85977ac834a11c563ea464cf18109d9026b1eb"

