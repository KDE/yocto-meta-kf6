# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/knotifications-6.13.0.tar.xz"
SRC_URI[sha256sum] = "d2b12f1d4ae80f700bc874112ecee99b1e44438c49bb2a8a77ceb4c70569f9dd"

