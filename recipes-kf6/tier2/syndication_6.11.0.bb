# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/syndication-6.11.0.tar.xz"
SRC_URI[sha256sum] = "d889c553a5189339217e8d06b628595aba3c842b74693e7a8179606b13629e1d"

