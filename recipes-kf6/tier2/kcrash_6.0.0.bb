# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kcrash-6.0.0.tar.xz"
SRC_URI[sha256sum] = "f56f1ed44e494417b7046e4f94791ad4ddd07c6cb8f0f704f2053717a44296f9"

