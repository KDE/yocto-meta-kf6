# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/knotifications-5.249.0.tar.xz"
SRC_URI[sha256sum] = "66b945919d0b9a8354be229969c7af20a01f27b0739fa1093f99ffe5e27f4a81"

