# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kcolorscheme-6.1.0.tar.xz"
SRC_URI[sha256sum] = "c30aa87f3a606807c4068dab0080392bdca49f8fbef18553e1a7de0f7c5b036a"

