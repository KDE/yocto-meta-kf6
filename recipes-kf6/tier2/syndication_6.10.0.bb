# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/syndication-6.10.0.tar.xz"
SRC_URI[sha256sum] = "a743c525e806e5f07b5b7b27cfe34882100b212b4d846e661c61a27ae1396330"

