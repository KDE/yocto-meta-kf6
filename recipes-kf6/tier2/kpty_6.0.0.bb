# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kpty-6.0.0.tar.xz"
SRC_URI[sha256sum] = "c5df357adfc1733593f6ceb3cd95ff7a3e587701f990b631dfaee0278e0df171"

