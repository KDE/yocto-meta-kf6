# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kpty-5.246.0.tar.xz"
SRC_URI[sha256sum] = "3c3391ba8bf4af5edc5030f486fd3292126e1eb09808802f1d43e9e071864926"

