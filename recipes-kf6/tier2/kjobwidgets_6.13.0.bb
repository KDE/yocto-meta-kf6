# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kjobwidgets-6.13.0.tar.xz"
SRC_URI[sha256sum] = "68f838812c4304212c0d25611c4251c27a8760885b3db22dfa909355c573b895"

