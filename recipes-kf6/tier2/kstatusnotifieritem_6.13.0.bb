# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kstatusnotifieritem-6.13.0.tar.xz"
SRC_URI[sha256sum] = "ed387fdee3dcb5bc3fa956ef6bb99bd2d4c0ed56ee5e2f1d89abaeb0c0b4de9a"

