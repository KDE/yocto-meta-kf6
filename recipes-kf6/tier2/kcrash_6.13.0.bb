# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kcrash-6.13.0.tar.xz"
SRC_URI[sha256sum] = "262e29adba445d3d00b25043e53c023f32a2c7dde11711c2a483c3536d57b95f"

