# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kpackage-6.7.0.tar.xz"
SRC_URI[sha256sum] = "916c11f5972760d9a5039643fbc55cde9d11ec18f278d3d63793336ffa442865"

