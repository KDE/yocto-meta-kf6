# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kpty-5.248.0.tar.xz"
SRC_URI[sha256sum] = "efdddde90431d68db4e83c73d0e10843d8d44bf76dbff08b3777640a853729ed"

