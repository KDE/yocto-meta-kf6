# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kstatusnotifieritem-6.3.0.tar.xz"
SRC_URI[sha256sum] = "ce1f2e33d0dbe81a48f0040977b7b7aa7234f6a003173e395b3de5d783398cd8"

