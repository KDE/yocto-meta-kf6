# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kunitconversion-6.3.0.tar.xz"
SRC_URI[sha256sum] = "7db3f42dd0ff3df4eb748ee62883e8f23203ca32d143d3fa09deb0651095079b"

