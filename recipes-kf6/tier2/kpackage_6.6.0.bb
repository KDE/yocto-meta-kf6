# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kpackage-6.6.0.tar.xz"
SRC_URI[sha256sum] = "12d77241586dc12baa3aa2c65bcebea31604216b91b76d9aaaabf370673e9ed2"

