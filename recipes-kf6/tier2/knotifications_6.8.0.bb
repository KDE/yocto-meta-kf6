# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/knotifications-6.8.0.tar.xz"
SRC_URI[sha256sum] = "1b39d77c025e06fd21c716000f51246810a2c5eb6da2a3f7fb3ce5de82ccf8af"

