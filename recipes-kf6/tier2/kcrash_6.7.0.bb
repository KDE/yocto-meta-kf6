# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kcrash-6.7.0.tar.xz"
SRC_URI[sha256sum] = "1dc2c65d8ef62ef98457f8ab423b7686de3e713766c06e64d6322aa9db26eea4"

