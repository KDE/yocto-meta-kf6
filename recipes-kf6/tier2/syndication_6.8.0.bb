# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/syndication-6.8.0.tar.xz"
SRC_URI[sha256sum] = "bfce2406fa4cf83f22911c1cd7dbafc2578b615f843368b55069b8ff630e2ba9"

