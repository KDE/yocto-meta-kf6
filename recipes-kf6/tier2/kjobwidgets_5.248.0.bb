# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kjobwidgets-5.248.0.tar.xz"
SRC_URI[sha256sum] = "31c5b079bc2dba3e03c47da637ab31767c09176304809539879c9989461d64a5"

