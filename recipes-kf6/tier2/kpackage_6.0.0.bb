# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kpackage-6.0.0.tar.xz"
SRC_URI[sha256sum] = "d2aec3df0dffb71e93acc03c46f2d4ca59c58263a9989df75107bf5223e9d1b7"

