# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kpackage-6.17.0.tar.xz"
SRC_URI[sha256sum] = "78d231a223394922d02957e17917a208de0e98224f21fc10e538ac971bdb42a4"

