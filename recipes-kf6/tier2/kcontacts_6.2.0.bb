# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kcontacts-6.2.0.tar.xz"
SRC_URI[sha256sum] = "709ca19e9076f98751764d029b8d648c6a61b17262ba4821cf97f913ccbd1bf9"

