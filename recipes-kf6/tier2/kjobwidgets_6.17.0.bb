# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kjobwidgets-6.17.0.tar.xz"
SRC_URI[sha256sum] = "0dc56de19bce3769b78c34dab1399588017180f298de8419eda1909a4211b624"

