# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kjobwidgets-6.18.0.tar.xz"
SRC_URI[sha256sum] = "e739ff254c4fa34c0de00aa2d9deee138135d99cd0b46ef5db253c18c02bce98"

