# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kcompletion-6.13.0.tar.xz"
SRC_URI[sha256sum] = "555ceacadbfd91a059dede3d9f06a9393858fdea12b5584135ad4139a2a7910a"

