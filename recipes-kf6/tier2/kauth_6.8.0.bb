# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kauth-6.8.0.tar.xz"
SRC_URI[sha256sum] = "bbf83a39870f756aaefb9afbd34e621d5fc53280c5eb70db9bd367fc51f8c749"

