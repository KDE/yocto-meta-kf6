# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kcompletion-5.248.0.tar.xz"
SRC_URI[sha256sum] = "a11fb0259d7fcb5867f39132b2b1fde7beb68e4c07b2542782914ff32cec3fb8"

