# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kunitconversion-6.2.0.tar.xz"
SRC_URI[sha256sum] = "e5ed60578ba4c3786a109ce1fb2e4b36e4825a79338c4aca1dddc9a493006e80"

