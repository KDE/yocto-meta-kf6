# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/syndication-5.246.0.tar.xz"
SRC_URI[sha256sum] = "fffcf81ee08c5e2bd50dd06f2b9bfeaf367c2004096ff2a784802d05d6f6ee7d"

