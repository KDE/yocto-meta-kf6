# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/syndication-6.4.0.tar.xz"
SRC_URI[sha256sum] = "d5637eaf255c4d3e110765d2ed5aba06c994560801e4e6c4b0698acc53954dcb"

