# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kstatusnotifieritem-5.245.0.tar.xz"
SRC_URI[sha256sum] = "44605dd80b06d96f93d492af13ea0cd6c59d67c0db273b640aa45b3b52c2962c"

