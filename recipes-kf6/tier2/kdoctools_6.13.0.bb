# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kdoctools-6.13.0.tar.xz"
SRC_URI[sha256sum] = "b5c5c025d269c839477f3f264c097af074e73f2b07ad1a8683367f395d2acaad"

