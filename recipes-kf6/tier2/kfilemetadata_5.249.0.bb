# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kfilemetadata-5.249.0.tar.xz"
SRC_URI[sha256sum] = "c8eba6e9ab486be83391d5ec8b34efbcb67ad855f108caf11ec4a57b52d1b8a4"

