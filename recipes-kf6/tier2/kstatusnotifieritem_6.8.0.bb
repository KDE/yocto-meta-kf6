# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kstatusnotifieritem-6.8.0.tar.xz"
SRC_URI[sha256sum] = "6e4ff81b80d7842d2a10e7b758e497b3724fc54ea3a6da6f09bee80636439832"

