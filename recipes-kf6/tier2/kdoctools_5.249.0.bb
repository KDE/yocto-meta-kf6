# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kdoctools-5.249.0.tar.xz"
SRC_URI[sha256sum] = "d25d772e2f0353e8484ae79270f83bf21e737dd98dec6aca7c4e20316a79fdf7"

