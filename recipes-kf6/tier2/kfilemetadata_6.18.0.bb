# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kfilemetadata-6.18.0.tar.xz"
SRC_URI[sha256sum] = "05c4b0955885b46fed6dc23998760fdae59599a960159ec44f779d7498a08834"

