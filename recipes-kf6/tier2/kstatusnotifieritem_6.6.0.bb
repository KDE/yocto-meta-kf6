# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kstatusnotifieritem-6.6.0.tar.xz"
SRC_URI[sha256sum] = "f2522bd1de0b02160f78aae0150c48a9ed299186884fb99d0a6fb80549e409dd"

