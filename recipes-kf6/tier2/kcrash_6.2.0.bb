# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kcrash-6.2.0.tar.xz"
SRC_URI[sha256sum] = "00b7b4885cb2a92e832816e9cc1da8cf5cccc4c4482c13648f020988c86cf588"

