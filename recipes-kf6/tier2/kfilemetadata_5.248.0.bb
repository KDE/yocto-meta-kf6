# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kfilemetadata-5.248.0.tar.xz"
SRC_URI[sha256sum] = "97f9228ac89bc71d93eb4b661a1d23decb897c9e5ce8c001fb044f7e69bd19dc"

