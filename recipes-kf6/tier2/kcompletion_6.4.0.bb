# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kcompletion-6.4.0.tar.xz"
SRC_URI[sha256sum] = "f08e2af5046a7ba5a324e475a9f107294b3b83e45e14d70e422f99dda1459d51"

