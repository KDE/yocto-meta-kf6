# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/knotifications-6.6.0.tar.xz"
SRC_URI[sha256sum] = "28153dce38eb488d228942a2ed197e57739107db1002448ad56bdd5be10bf60d"

