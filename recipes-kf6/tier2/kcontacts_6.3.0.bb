# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kcontacts-6.3.0.tar.xz"
SRC_URI[sha256sum] = "229b5b1797cdc7faeb227f715c86edee8e8464f40b247432af909e3b3d30b107"

