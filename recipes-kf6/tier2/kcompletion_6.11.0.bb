# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kcompletion-6.11.0.tar.xz"
SRC_URI[sha256sum] = "c812b60de4530de3003916e45fbab121c5f9f576e2430ab2cdf0e3e4c9041852"

