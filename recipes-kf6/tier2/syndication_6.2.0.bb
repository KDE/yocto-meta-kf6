# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/syndication-6.2.0.tar.xz"
SRC_URI[sha256sum] = "50ec3843a08ec7b185352c94b89bc2d2720ceaf17eb961a4c3da55f93d05af3c"

