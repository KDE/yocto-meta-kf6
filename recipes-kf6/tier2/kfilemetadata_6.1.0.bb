# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kfilemetadata-6.1.0.tar.xz"
SRC_URI[sha256sum] = "d52a782c54eae5da32912ca876f1975fb7e4bffe1cb1e17226d83614ab3bb1ca"

