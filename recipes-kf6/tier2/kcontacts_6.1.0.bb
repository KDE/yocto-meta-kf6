# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kcontacts-6.1.0.tar.xz"
SRC_URI[sha256sum] = "bed0be5b8302cf4d749120234c98d0dc629da04a0123694138681a022184264e"

