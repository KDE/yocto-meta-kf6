# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kpty-6.13.0.tar.xz"
SRC_URI[sha256sum] = "afa8fa8c579bd2ca4b0cccc69427f9035fa7d76cefe258639ec17d966aa43513"

