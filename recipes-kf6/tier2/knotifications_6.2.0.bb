# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/knotifications-6.2.0.tar.xz"
SRC_URI[sha256sum] = "9627c200f58de5e5dc4e74d1a13005624115b6d23da034e64aa1bf3143e78164"

