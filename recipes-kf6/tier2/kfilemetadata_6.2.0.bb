# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kfilemetadata-6.2.0.tar.xz"
SRC_URI[sha256sum] = "106941654024b6165da3fac2622fbebd35ff09f08345ad93a2b2c1abfa177e30"

