# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kfilemetadata-5.245.0.tar.xz"
SRC_URI[sha256sum] = "1290b836c88231488b319967d384c3c807c77de816ef7265a8e488e777231796"

