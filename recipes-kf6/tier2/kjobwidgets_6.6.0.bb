# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kjobwidgets-6.6.0.tar.xz"
SRC_URI[sha256sum] = "3c8eccd89d4118b6ecd619106f93a9b156df5899465b820d4b65d969813db515"

