# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kpackage-6.11.0.tar.xz"
SRC_URI[sha256sum] = "bfc704ea1708f37150a9d14edcbb9eed8ebf8d54753930da63432cda954a1ea7"

