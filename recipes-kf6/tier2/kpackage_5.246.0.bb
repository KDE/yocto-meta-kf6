# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kpackage-5.246.0.tar.xz"
SRC_URI[sha256sum] = "90e4e360427738f03df9eb57df2f085f5a9e371e8457d3981cebfa667eabdb91"

