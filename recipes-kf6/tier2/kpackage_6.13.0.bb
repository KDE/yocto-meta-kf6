# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kpackage-6.13.0.tar.xz"
SRC_URI[sha256sum] = "a622694aa723d79b7b4988cb2bc51f85d20fcaafee020f741ee52053dc85648a"

