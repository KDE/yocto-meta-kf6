# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kimageformats-6.11.0.tar.xz"
SRC_URI[sha256sum] = "0c45787f97d00fc0257f7de3250d84e950de2a332c45e7528138f7cf843154cc"

