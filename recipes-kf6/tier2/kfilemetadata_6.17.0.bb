# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kfilemetadata-6.17.0.tar.xz"
SRC_URI[sha256sum] = "2bb9a99846ab0f73636ec34fba244908a123591f7f7458bab91b8cfb23923044"

