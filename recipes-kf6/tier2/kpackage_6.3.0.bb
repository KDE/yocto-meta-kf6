# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kpackage-6.3.0.tar.xz"
SRC_URI[sha256sum] = "811d6809e091c1eaaa07cafeacc86eb23fa55ed038f8f1a93d259e5734510b4d"

