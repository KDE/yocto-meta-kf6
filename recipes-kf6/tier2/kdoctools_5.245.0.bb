# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kdoctools-5.245.0.tar.xz"
SRC_URI[sha256sum] = "042084741bf79d527f0ad92afe9629e595c476a90fe85e946888192b3f89aff2"

