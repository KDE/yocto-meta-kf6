# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kpackage-5.245.0.tar.xz"
SRC_URI[sha256sum] = "f179a1aa8a12c699d18dc5ce2aa8bdedd86a429b10b4ecc9259370bed73cb273"

