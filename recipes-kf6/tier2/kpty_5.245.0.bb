# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kpty-5.245.0.tar.xz"
SRC_URI[sha256sum] = "493f90ff66be6bcee25416753f217ee81d6d9173dbadf03d3d1edd4410f9a958"

