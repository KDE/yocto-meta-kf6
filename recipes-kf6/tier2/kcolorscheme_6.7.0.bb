# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kcolorscheme-6.7.0.tar.xz"
SRC_URI[sha256sum] = "1b4c6e84f1dd96b2ee62be755f60da60d61ba80d6709eeb3186d8882e72e2130"

