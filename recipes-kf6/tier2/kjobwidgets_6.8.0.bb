# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kjobwidgets-6.8.0.tar.xz"
SRC_URI[sha256sum] = "86f2301dd9be85e62dee697875ff5a731863db083233b4b0c6049dab64a98501"

