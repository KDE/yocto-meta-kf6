# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kcompletion-5.245.0.tar.xz"
SRC_URI[sha256sum] = "8d7379a192114f4eb99fc3f7613d07686173dc44449753f6af74a6cc361266aa"

