# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kcolorscheme-6.2.0.tar.xz"
SRC_URI[sha256sum] = "0990c172c5b12996b7c0be3c2e53530cef65eaf76d192854cf207872fba95f1b"

