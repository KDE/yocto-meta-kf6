# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kimageformats-6.4.0.tar.xz"
SRC_URI[sha256sum] = "fd7bdab88e7bcccb333879eb28dedf35842c110c057ff4c7d3fa77708e541296"

