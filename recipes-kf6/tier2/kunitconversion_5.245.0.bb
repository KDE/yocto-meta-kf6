# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kunitconversion-5.245.0.tar.xz"
SRC_URI[sha256sum] = "17b8f406f3260bc439faf975081e05f27f30f92d2fb74c67f20302e43f5ee9cd"

