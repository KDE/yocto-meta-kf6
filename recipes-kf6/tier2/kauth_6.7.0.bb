# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kauth-6.7.0.tar.xz"
SRC_URI[sha256sum] = "173654eee2891acd41538d31ace8b9d7ae60863bc7faef1cacec7e21c7eb1223"

