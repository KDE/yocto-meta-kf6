# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kpackage-6.10.0.tar.xz"
SRC_URI[sha256sum] = "0f49c1cdb49e01c6dce372abbc9814ccbd74b7f2b130c7310674345e3498cec1"

