# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kunitconversion-6.11.0.tar.xz"
SRC_URI[sha256sum] = "8d26a83d1371bd70c48281708680c69e61faca44963deab52d07c9723c27ee49"

