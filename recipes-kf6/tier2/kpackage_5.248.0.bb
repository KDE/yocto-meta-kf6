# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kpackage-5.248.0.tar.xz"
SRC_URI[sha256sum] = "d23054e60cadc8bbb9f0bf5711826e4d64938cb25f0d0a0d8f3606c071285975"

