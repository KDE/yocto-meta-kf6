# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kjobwidgets-5.245.0.tar.xz"
SRC_URI[sha256sum] = "501b70589a780c224d2824ce2b008ca3d8908dfe0b4e736e668d1f29bfbdaaa2"

