# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kimageformats-6.6.0.tar.xz"
SRC_URI[sha256sum] = "1b4cda14f96088f8de190c9be7fbe350a80a55c3ee2a8ff910da0d9992c4ddaf"

