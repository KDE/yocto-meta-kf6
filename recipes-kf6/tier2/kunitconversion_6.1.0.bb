# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kunitconversion-6.1.0.tar.xz"
SRC_URI[sha256sum] = "df6de6f2d41b3943b31ccec051013cb0d4fc6e9979a8e5232e6436e390b331ec"

