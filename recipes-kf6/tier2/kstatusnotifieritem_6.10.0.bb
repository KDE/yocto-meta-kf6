# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kstatusnotifieritem-6.10.0.tar.xz"
SRC_URI[sha256sum] = "4fa19843a737b43674d19b9ad31466c6aa64bbe27709073c3e2c33aa03bfac22"

