# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kjobwidgets-6.3.0.tar.xz"
SRC_URI[sha256sum] = "5fee2d4b9479fac74422790c3ea2b1464b4ae3f10347fc603a41d8b167f108d8"

