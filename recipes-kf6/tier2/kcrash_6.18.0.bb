# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kcrash-6.18.0.tar.xz"
SRC_URI[sha256sum] = "a66293821b151f575fcfb59848578749e248c5baa2f262ac86725d0f64b324e0"

