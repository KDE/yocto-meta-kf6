# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kstatusnotifieritem-5.249.0.tar.xz"
SRC_URI[sha256sum] = "b4485d37226758b4b43c4ebd7fe344b65e2408334f778a3deecef71315451f40"

