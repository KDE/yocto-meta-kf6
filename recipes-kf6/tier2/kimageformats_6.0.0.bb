# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kimageformats-6.0.0.tar.xz"
SRC_URI[sha256sum] = "1ddd28f2fb8ac2c95556f792418c2b6190a04050ac31b27aa82ea11c1af0879c"

