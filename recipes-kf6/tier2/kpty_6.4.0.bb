# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kpty-6.4.0.tar.xz"
SRC_URI[sha256sum] = "68626789dcb79d9fd1b3a4c55016747260085ba4c68f7b408a5f1d190cca4623"

