# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kfilemetadata-6.0.0.tar.xz"
SRC_URI[sha256sum] = "cf130dc1b32a31a19213f3e1ac67f2180cb7931240e5c755211686e93792f393"

