# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kcontacts-6.8.0.tar.xz"
SRC_URI[sha256sum] = "463822616f11da2368fafed8f71e1c98ad47103c89dbfa8c88fe65a41ae15051"

