# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/syndication-6.7.0.tar.xz"
SRC_URI[sha256sum] = "c2a485229d8a430858d7f473fe8b133737d93d33a776e46eedfa77bb9e30ba24"

