# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kjobwidgets-6.1.0.tar.xz"
SRC_URI[sha256sum] = "ac79ddb48b38527a605a9564485ad370cbcfdb406b95e0f9255d55256454fdb8"

