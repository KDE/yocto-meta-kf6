# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kstatusnotifieritem-5.248.0.tar.xz"
SRC_URI[sha256sum] = "c4ce526873f6e8042fb6c5b51d78289d1d572bc5aca24be81193b1aca759034c"

