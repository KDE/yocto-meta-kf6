# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kpty-6.18.0.tar.xz"
SRC_URI[sha256sum] = "3f800638fcc0dbea0810930a1f2decfa6b894bb00732ff8646182c7dfd2ac76d"

