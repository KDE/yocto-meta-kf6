# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kcontacts-6.18.0.tar.xz"
SRC_URI[sha256sum] = "a532c47c3c2c8182b2ae9e783ff521311896251c2a1ddbe364b3491f94c100b6"

