# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kcolorscheme-6.18.0.tar.xz"
SRC_URI[sha256sum] = "14e99e74cc636640ac8d705f2878d72d0379fff671e75c0f138302489898d651"

