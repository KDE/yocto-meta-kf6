# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kauth-6.10.0.tar.xz"
SRC_URI[sha256sum] = "be25601b91b129a48e497231be2513a1eb8c9707a82d38395561656d1df10988"

