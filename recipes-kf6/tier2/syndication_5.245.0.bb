# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/syndication-5.245.0.tar.xz"
SRC_URI[sha256sum] = "49c014661d9b7c98735fa30b21895f46964ce9e3406632c9d3db43bbfffe0fa2"

