# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kpty-6.10.0.tar.xz"
SRC_URI[sha256sum] = "1fccd92d67eac0bfeadac3badbb409dcd720ed224284ed056166ab5787f2d647"

