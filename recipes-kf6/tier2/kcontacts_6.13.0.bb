# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kcontacts-6.13.0.tar.xz"
SRC_URI[sha256sum] = "c3f389f9e41f2aaebe5c6b2c6fbc33927f64423cb24cc240f61e93dbc057506f"

