# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kpty-6.1.0.tar.xz"
SRC_URI[sha256sum] = "df226cd90ba6f773560404c799562b2764ad39d4f41f15105f2ed9f9b2cf59df"

