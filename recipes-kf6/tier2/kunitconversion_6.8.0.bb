# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kunitconversion-6.8.0.tar.xz"
SRC_URI[sha256sum] = "e620547881e635cc8aa9771a6eca9a97a6cb40925ac075d33ef7744facc1d954"

