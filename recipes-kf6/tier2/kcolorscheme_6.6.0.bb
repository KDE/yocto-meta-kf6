# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kcolorscheme-6.6.0.tar.xz"
SRC_URI[sha256sum] = "657839e1ff8141ff09705be912e276a2dc98df122f5bcc2fdc3ed11d10100cd1"

