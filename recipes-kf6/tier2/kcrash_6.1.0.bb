# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kcrash-6.1.0.tar.xz"
SRC_URI[sha256sum] = "727f82e9767c2f647b7ee6bd79d51ebd40691271320dcb7835a30cf8806479ed"

