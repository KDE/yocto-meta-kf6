# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kimageformats-6.17.0.tar.xz"
SRC_URI[sha256sum] = "180b670f766bae740340e5afd2044ea08242ea935459bb95bc80313d062066a8"

