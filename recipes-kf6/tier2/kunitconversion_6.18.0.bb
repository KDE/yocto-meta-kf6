# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kunitconversion-6.18.0.tar.xz"
SRC_URI[sha256sum] = "23a4a5d994666f9db2a5a3c251038f2ef1d978411950925702fb79060ced31c8"

