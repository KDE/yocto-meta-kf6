# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kcontacts-6.17.0.tar.xz"
SRC_URI[sha256sum] = "198db25bdc7e7fee11766effed13ad4438f6a211be8a16a1cd1e815e3ebcf21a"

