# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kauth-6.0.0.tar.xz"
SRC_URI[sha256sum] = "66046698d2584692d5397a6ec808b2c9f8b7882a0f85233be9cd69283d03c768"

