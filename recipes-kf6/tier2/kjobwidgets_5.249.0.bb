# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kjobwidgets-5.249.0.tar.xz"
SRC_URI[sha256sum] = "b572b00fc5bbd075dadc902c0b9543d4c8e0f79b7cc7a113cbf823e3c5e5a634"

