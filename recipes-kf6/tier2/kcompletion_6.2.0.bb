# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kcompletion-6.2.0.tar.xz"
SRC_URI[sha256sum] = "58cb938eb111e8859dd1baa51062467f226b8c67cb1fdb98748d3e97fabf08e9"

