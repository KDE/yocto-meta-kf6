# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kstatusnotifieritem-6.11.0.tar.xz"
SRC_URI[sha256sum] = "26c92c25b1f70296bde9e71fba1f719778c85cb57227f6045f606af99c48a8bd"

