# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kcolorscheme-6.0.0.tar.xz"
SRC_URI[sha256sum] = "de45822431755be39ab7aebfcb7cb6ff90b4924579c2a4d66ae28f91d70a260e"

