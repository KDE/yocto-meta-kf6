# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/knotifications-6.7.0.tar.xz"
SRC_URI[sha256sum] = "9e972f015d9b31b3283bf842a32d270096224d127c13a6e79450f4f0452de5e7"

