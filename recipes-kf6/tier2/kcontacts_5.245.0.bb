# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kcontacts-5.245.0.tar.xz"
SRC_URI[sha256sum] = "e65649b83fb99ce5ed16107d268e0e138ba0471585ab4a84cf3ce6f955a9ad38"

