# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kcolorscheme-5.249.0.tar.xz"
SRC_URI[sha256sum] = "66bd0225e7557474760b3bc2b2866d868b36d0035212135ceb43fc356b361236"

