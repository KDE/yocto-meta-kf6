# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/syndication-5.248.0.tar.xz"
SRC_URI[sha256sum] = "f9a50c6e4f9bbf7c20add07bd345018ec6718d9099c127aa6c49566994a9e847"

