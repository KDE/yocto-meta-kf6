# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kdoctools-6.1.0.tar.xz"
SRC_URI[sha256sum] = "240254adbb52184a571072068bf504bbc3579eb9811983c6a3795563260ef3b5"

