# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kpty-6.8.0.tar.xz"
SRC_URI[sha256sum] = "fbc7f390a0b8397a5163f16b140c0662c994f614a05f7e5a5161493c3cbc3e36"

