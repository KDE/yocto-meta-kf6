# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kfilemetadata-6.13.0.tar.xz"
SRC_URI[sha256sum] = "090fcd05577cd7940e7072fcf8855f1a7f076ff09ae3397bbfa40681dea4be9e"

