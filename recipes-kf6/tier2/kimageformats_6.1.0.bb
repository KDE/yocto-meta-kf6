# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kimageformats-6.1.0.tar.xz"
SRC_URI[sha256sum] = "b033fa058ab4c9657e1bcd682a89ca94a5b881e7904dddee6aab4a14bafcc95e"

