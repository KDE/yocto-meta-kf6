# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kfilemetadata-6.7.0.tar.xz"
SRC_URI[sha256sum] = "a6242a79e672b523ebf1b2554ebf83aca7a9d5065929b6f152731e9851d008d0"

