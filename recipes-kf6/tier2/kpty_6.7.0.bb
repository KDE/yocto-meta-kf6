# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kpty-6.7.0.tar.xz"
SRC_URI[sha256sum] = "42cc1b1f70ee0bdacd26812857d31047d218e1f585ac35fe9165908501a9946a"

