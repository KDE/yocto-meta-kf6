# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kstatusnotifieritem-6.17.0.tar.xz"
SRC_URI[sha256sum] = "678a9bfc870066d5413bbcfa09a56b82b0affd2bc222ce5701d02a8b129edd91"

