# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kunitconversion-6.13.0.tar.xz"
SRC_URI[sha256sum] = "208f037e8089f999e0bb0aaf85571b3a2d341cd8e40c111b35ead9d2610017ea"

