# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kstatusnotifieritem-6.7.0.tar.xz"
SRC_URI[sha256sum] = "80eae2693cdb5da669b4ed6a8228bddc39816aca0fde928f231e4894827d1de0"

