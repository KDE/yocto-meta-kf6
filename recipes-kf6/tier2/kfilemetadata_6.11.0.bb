# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kfilemetadata-6.11.0.tar.xz"
SRC_URI[sha256sum] = "f9190969eaf66f9d27690cc3b85a3d19395ee3657582c9ae6c94c49a113312c7"

