# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kcontacts-6.7.0.tar.xz"
SRC_URI[sha256sum] = "292f8104f9f31d62c59289a3a821766d1ec540f4fc513ffc3b6f7197602d42c5"

