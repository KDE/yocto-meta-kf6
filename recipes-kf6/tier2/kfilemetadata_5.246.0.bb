# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kfilemetadata-5.246.0.tar.xz"
SRC_URI[sha256sum] = "cd84d2045f70009bc30ba15dc8320541aff527fae069690672a6d8c69bc77aee"

