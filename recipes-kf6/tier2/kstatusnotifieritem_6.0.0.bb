# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kstatusnotifieritem-6.0.0.tar.xz"
SRC_URI[sha256sum] = "b426176d2cbc6fe80c758b6c476a47341d89a92cbb3355c2be37428a41772907"

