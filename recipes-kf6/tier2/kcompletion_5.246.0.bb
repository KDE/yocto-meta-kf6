# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kcompletion-5.246.0.tar.xz"
SRC_URI[sha256sum] = "2043befa7a696211b32bfc32baecbf4010a2be7b4b158220843328ea5763cdce"

