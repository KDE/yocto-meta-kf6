# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kimageformats-6.7.0.tar.xz"
SRC_URI[sha256sum] = "722850648ac167e4c0ee631571fde49e9fd15d004a127dd804a14f9f579b731f"

