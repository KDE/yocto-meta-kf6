# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kunitconversion-5.249.0.tar.xz"
SRC_URI[sha256sum] = "dfdb4a930b9b5a3c337d55ae7f3736c6f423a26e28178457ba8329ef038cb28d"

