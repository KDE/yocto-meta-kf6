# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kcolorscheme-6.11.0.tar.xz"
SRC_URI[sha256sum] = "8b27bddb830f0173f44ae9aac05213579909b85fa696a2871b2ee11cb239bcc8"

