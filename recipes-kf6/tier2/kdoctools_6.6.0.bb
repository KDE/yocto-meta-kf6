# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kdoctools-6.6.0.tar.xz"
SRC_URI[sha256sum] = "149e0b442290f8bc9d2a0c99c8e27a5735a3a83870a82de007e487529f0aad44"

