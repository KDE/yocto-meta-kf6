# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kstatusnotifieritem-6.1.0.tar.xz"
SRC_URI[sha256sum] = "93e2c9caa70d4cce8059aa6cb81e5b161d405701db184ddff81303fa24fdef14"

