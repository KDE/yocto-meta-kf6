# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kcrash-6.4.0.tar.xz"
SRC_URI[sha256sum] = "011215bc952a430c1d093b0bf5cdad7057c9a9098d86116e69c6dd1000567697"

