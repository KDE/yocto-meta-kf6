# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kcrash-6.8.0.tar.xz"
SRC_URI[sha256sum] = "a702944c87c9634eefd52293f625355314473e6c4c24b472ee7854cb8c68957f"

