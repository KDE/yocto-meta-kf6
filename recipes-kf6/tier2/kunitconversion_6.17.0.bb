# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kunitconversion-6.17.0.tar.xz"
SRC_URI[sha256sum] = "f2625a4ba25b3329fb9730249073bcd349b7a346362148c7fa97989efc7e5cca"

