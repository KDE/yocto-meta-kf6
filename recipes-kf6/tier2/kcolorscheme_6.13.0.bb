# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kcolorscheme-6.13.0.tar.xz"
SRC_URI[sha256sum] = "8ab8a567bdb8b83f64824ad3d449077ecb92f73024314f55eeab7777d9129edf"

