# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kcontacts-5.248.0.tar.xz"
SRC_URI[sha256sum] = "9ce7b97474c589d3573a415c643f3bbca0bc154844456d3a9d7ca613d11c5f6f"

