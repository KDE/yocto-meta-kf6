# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kcompletion-6.18.0.tar.xz"
SRC_URI[sha256sum] = "6d06881ff2ece4c29df5c3cbe3700cb5e3425064686a667e84f06f2a5732a1c5"

