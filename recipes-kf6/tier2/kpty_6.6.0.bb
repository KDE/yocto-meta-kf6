# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kpty-6.6.0.tar.xz"
SRC_URI[sha256sum] = "63a1deb95284c8ff2fb77404a81183dd77d96458d05110b468742b3a0f755e61"

