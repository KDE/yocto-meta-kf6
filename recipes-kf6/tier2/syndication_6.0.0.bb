# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/syndication-6.0.0.tar.xz"
SRC_URI[sha256sum] = "ff5e5189fcf8f6fb1289886ea370c20295de8c07269521316c2548b8e7294bad"

