# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kimageformats-6.18.0.tar.xz"
SRC_URI[sha256sum] = "9d373ef5362aa8d71541cec2895415c95ca914626dcb0dd6b0ceef491dcbae46"

