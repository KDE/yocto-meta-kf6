# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/frameworkintegration-6.8.0.tar.xz"
SRC_URI[sha256sum] = "141bc59dfdb246c90501a488cbf013b9f0bbc1c27a78f2f25744339576edaf37"

