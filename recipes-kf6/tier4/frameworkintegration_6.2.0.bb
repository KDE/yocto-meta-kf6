# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/frameworkintegration-6.2.0.tar.xz"
SRC_URI[sha256sum] = "e41f64b178ad9dadcad51b145bd580868aba061fb80ff15614268d09ec4e0d7c"

