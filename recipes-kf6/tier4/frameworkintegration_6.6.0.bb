# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/frameworkintegration-6.6.0.tar.xz"
SRC_URI[sha256sum] = "ea594c3957a09fdcb85711d4bdff6d923c0e3eb8ec496e5686585fc56723d3a0"

