# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/frameworkintegration-5.245.0.tar.xz"
SRC_URI[sha256sum] = "babd4a9bbefa0aa8e799eb1f9452e14c0d42f7f8fb78eae102e159cb15b44320"

