# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/frameworkintegration-6.1.0.tar.xz"
SRC_URI[sha256sum] = "47bb38a778b94405bd9e251be774ba910c2b85cd6a4512ba1f6e9b6f879144e8"

