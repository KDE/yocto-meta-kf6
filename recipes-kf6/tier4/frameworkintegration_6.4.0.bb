# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/frameworkintegration-6.4.0.tar.xz"
SRC_URI[sha256sum] = "4682d15c3a2e49785eda8f6c309e5f30d82ff6a5bcc39228544374c64199ef71"

