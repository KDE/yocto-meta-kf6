# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/frameworkintegration-5.246.0.tar.xz"
SRC_URI[sha256sum] = "4e8f046f1f4e987a58c9f5fe53b28f23d5b0bc74970a123ea23cbc448b74a481"

