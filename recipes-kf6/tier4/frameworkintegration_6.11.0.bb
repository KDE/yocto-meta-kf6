# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/frameworkintegration-6.11.0.tar.xz"
SRC_URI[sha256sum] = "a7447a587040284463846a479e01b7d821c89b5f3b8683cbb367f568cea81fb2"

