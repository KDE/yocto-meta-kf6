# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/frameworkintegration-6.10.0.tar.xz"
SRC_URI[sha256sum] = "61fc35cffb0863517fa2072b96476bf109499d58fb3264062b40be528dd3af82"

