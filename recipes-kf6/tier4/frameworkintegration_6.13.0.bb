# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/frameworkintegration-6.13.0.tar.xz"
SRC_URI[sha256sum] = "182b911c9a08de9890c2427e8a1cfc202b4ae05aea37c6d939a449bfa987f31f"

