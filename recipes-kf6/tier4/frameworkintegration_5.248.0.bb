# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/frameworkintegration-5.248.0.tar.xz"
SRC_URI[sha256sum] = "b12954b576d5461e9cd677d32f8da2d1321fae4be20270b69137d57747699b32"

