# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/frameworkintegration-6.18.0.tar.xz"
SRC_URI[sha256sum] = "cc5336f8ed19da061f766d4854d76e9cd424ac4082cb44dfb4e7cf136aeab454"

