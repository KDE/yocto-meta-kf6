# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/frameworkintegration-6.7.0.tar.xz"
SRC_URI[sha256sum] = "890101854bbbb3937d321f2ac35b2a0a8f3ce833422297ddda59bda8c8cac69d"

