# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/frameworkintegration-5.249.0.tar.xz"
SRC_URI[sha256sum] = "2bc1ac647c5918f73518c726c2adbc7e0125aa40d03ed2370abb393aa7d04d95"

