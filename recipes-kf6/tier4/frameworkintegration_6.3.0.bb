# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/frameworkintegration-6.3.0.tar.xz"
SRC_URI[sha256sum] = "94700551b3373f792b27ea6ca3013c7bda8f6b63260b918b3c1eec0d83ad4c7f"

