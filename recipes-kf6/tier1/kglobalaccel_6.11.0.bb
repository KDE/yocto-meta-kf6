# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kglobalaccel-6.11.0.tar.xz"
SRC_URI[sha256sum] = "0552e4e5c58a244733af49cfdd0c8fc04a63828b6c2346b36820222d5e3bcef5"

