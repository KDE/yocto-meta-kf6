# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/bluez-qt-6.7.0.tar.xz"
SRC_URI[sha256sum] = "b0640106986213e1b28f2cba13d9cc22ee3d259755f27521f2e861634338f93b"

