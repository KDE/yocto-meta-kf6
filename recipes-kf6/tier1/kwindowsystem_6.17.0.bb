# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kwindowsystem-6.17.0.tar.xz"
SRC_URI[sha256sum] = "259abef58b09ad1a8022b5cb94831a98f3e5b5cc7c65f7a0b40be64361756f63"

