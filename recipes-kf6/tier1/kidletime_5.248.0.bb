# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kidletime-5.248.0.tar.xz"
SRC_URI[sha256sum] = "bc50a7ab9d88bd18cabec8765a66288f966fd2997943393a1b6275f3a2ae463a"

