# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kholidays-6.18.0.tar.xz"
SRC_URI[sha256sum] = "49dc892d98ee493a696dd730f5a0e1624b46ca7d746a2877f057007abe9f2151"

