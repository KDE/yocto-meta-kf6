# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kdnssd-6.2.0.tar.xz"
SRC_URI[sha256sum] = "509011367c11c3b17034d743ea6934951a6fc525b9527d18c38af81f60b08f45"

