# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/solid-6.18.0.tar.xz"
SRC_URI[sha256sum] = "7768c1da7ee34a9e37cfb6b5b727e690c80134ca424b5262e403e48ccf812ddf"

