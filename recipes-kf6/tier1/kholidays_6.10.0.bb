# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kholidays-6.10.0.tar.xz"
SRC_URI[sha256sum] = "788efeca7a5524c5a668623aba830ad6d875aa2711f0cac5f2329add2ab4458d"

