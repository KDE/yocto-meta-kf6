# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/modemmanager-qt-6.8.0.tar.xz"
SRC_URI[sha256sum] = "0a22eeca5afcf7b42059bbdf506924f25bad14df737c884fa8fd3e275e3a171b"

