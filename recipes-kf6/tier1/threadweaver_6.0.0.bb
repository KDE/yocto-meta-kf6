# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/threadweaver-6.0.0.tar.xz"
SRC_URI[sha256sum] = "ba9daec6e0697fdc2accf74a46a6d59403e5e340d280bce916fd6356a668ddb3"

