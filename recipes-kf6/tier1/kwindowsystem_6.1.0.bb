# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kwindowsystem-6.1.0.tar.xz"
SRC_URI[sha256sum] = "8c07543883aaa38b01508f06b4439559d890770006f8e9f6e8e769c5d4226595"

