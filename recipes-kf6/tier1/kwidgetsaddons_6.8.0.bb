# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kwidgetsaddons-6.8.0.tar.xz"
SRC_URI[sha256sum] = "cf8666ec0f0a720feab641ea3e195af1406a40080d118d1cf4ffaf123c6fab08"

