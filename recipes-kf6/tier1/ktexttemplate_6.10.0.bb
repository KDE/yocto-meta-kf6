# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/ktexttemplate-6.10.0.tar.xz"
SRC_URI[sha256sum] = "3e39190adb90d4f71672e33d117b35fe84a8f35aaa90a678846401044894aa3d"

