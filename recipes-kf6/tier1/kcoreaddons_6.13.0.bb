# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kcoreaddons-6.13.0.tar.xz"
SRC_URI[sha256sum] = "a110bc3303c541fbac3e2d3aa93c2eb25413055de24634a69034210f6dfddbdb"

