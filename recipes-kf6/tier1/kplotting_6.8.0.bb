# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kplotting-6.8.0.tar.xz"
SRC_URI[sha256sum] = "736c95f7761ca062585ed2b5b72656b9bb6a5e706548cbd9f07da4f62c8fba8b"

