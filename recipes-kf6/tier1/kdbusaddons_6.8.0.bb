# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kdbusaddons-6.8.0.tar.xz"
SRC_URI[sha256sum] = "6c760a0dc372af0a2f825b65575bfabd1950c76c0e37f87de21d47cec8d58bc7"

