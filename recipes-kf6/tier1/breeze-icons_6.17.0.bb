# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/breeze-icons-6.17.0.tar.xz"
SRC_URI[sha256sum] = "4ffc75886e9a14a2a02da4871600b8c0b5a40756b8e99cbecfb515696d93c3b8"

