# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/bluez-qt-5.246.0.tar.xz"
SRC_URI[sha256sum] = "bcec88a1750a797e81aab50ea48bb84f3b9fe23ea19294285303c2a731ea1655"

