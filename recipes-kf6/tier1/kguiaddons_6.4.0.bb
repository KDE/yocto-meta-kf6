# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kguiaddons-6.4.0.tar.xz"
SRC_URI[sha256sum] = "e1c25df0b8095be2497d2041e71cc843eaf75a6707f65b1cd74386fe3262cf11"

