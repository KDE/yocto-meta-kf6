# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kitemviews-6.0.0.tar.xz"
SRC_URI[sha256sum] = "aded76af78d66bc3e90f3a1cada117d74783b519904d04a39591b9874df35243"

