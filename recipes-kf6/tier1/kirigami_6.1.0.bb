# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kirigami-6.1.0.tar.xz"
SRC_URI[sha256sum] = "2a5438186b6cf8847a579c030fed3778638e5fb4e5eb54f71dc2602da4607196"

