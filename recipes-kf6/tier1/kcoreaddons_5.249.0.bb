# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kcoreaddons-5.249.0.tar.xz"
SRC_URI[sha256sum] = "846cca6127ceb6043d753a66127771a22496b6d2a9152b626d669ce813cca64b"

