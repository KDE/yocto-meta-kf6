# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kidletime-6.13.0.tar.xz"
SRC_URI[sha256sum] = "ee17d3f7cdd507390e0e9ba96896b7dcfaa008e385a9db423207bc3ee236e6dc"

