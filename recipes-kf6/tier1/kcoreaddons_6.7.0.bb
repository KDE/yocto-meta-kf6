# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kcoreaddons-6.7.0.tar.xz"
SRC_URI[sha256sum] = "48511e9dab1f2e80b3c4822bb87c2e981186de3b8977d92082d34d003b1283c5"

