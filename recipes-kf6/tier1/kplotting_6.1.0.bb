# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kplotting-6.1.0.tar.xz"
SRC_URI[sha256sum] = "bb21319725b20382a44a9be2d70c76a5eb58e6c80cf28b6f314f49e9cb73b1fa"

