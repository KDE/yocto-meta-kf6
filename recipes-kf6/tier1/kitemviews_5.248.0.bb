# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kitemviews-5.248.0.tar.xz"
SRC_URI[sha256sum] = "ba07feb554410b226e274cbf6d331125c108c06c28a7d0e365daddb44f7770f0"

