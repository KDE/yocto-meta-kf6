# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kitemviews-6.8.0.tar.xz"
SRC_URI[sha256sum] = "eb6831fdbfeda3328500ff0f3f57b0901c04cfbe73a5a73837ae0b11b22925af"

