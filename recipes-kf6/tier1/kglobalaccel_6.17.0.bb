# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kglobalaccel-6.17.0.tar.xz"
SRC_URI[sha256sum] = "fc3d4055542639145b3e45068264745c611fc3ecf0d0144eaa3532038fa971f1"

