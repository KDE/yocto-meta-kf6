# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kguiaddons-6.17.0.tar.xz"
SRC_URI[sha256sum] = "5d07dbc8e24ab1077de75b7830a1f362dff3710fb041d61b8da02c577056ab6b"

