# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/attica-6.8.0.tar.xz"
SRC_URI[sha256sum] = "44300a2d0ed465d9adb0023fac6d67b3b29bec299a54fea3ff3477d9118d1fdd"

