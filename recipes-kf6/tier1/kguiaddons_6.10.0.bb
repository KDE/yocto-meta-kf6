# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kguiaddons-6.10.0.tar.xz"
SRC_URI[sha256sum] = "b3be04077313e559c5a8f66491d5d286cefe947aaf7c8937544ce85af4853ffa"

