# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kidletime-6.11.0.tar.xz"
SRC_URI[sha256sum] = "96efb0b533a37ddb2e1888dff7d4722c19c47d660f74d1b0a422eb95718f4882"

