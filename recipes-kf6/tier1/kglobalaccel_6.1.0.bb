# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kglobalaccel-6.1.0.tar.xz"
SRC_URI[sha256sum] = "885b13d3888eebe585589dc288e3826044ab5bf3b8e2a749b9070d93d32f64f2"

