# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kholidays-6.17.0.tar.xz"
SRC_URI[sha256sum] = "5b8e7df887bf790eddd6533910eefa9b00a77f2675260da71f36b95cb764fab2"

