# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/modemmanager-qt-6.7.0.tar.xz"
SRC_URI[sha256sum] = "fc45dcd8ada243baf7900099062f312b677bf694f88f36746d534afe907bf8f3"

