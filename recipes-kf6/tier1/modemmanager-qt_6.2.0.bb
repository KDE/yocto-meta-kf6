# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/modemmanager-qt-6.2.0.tar.xz"
SRC_URI[sha256sum] = "f3d1db9ac64a353334b074e45cd07fce4b40ac1388c964f8b269746dc35beea8"

