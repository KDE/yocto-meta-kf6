# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/extra-cmake-modules-5.248.0.tar.xz"
SRC_URI[sha256sum] = "62c0cf9c3333e41a41e7cbb47bf18a123d5328587a7563f2af52a042f9a2b802"

