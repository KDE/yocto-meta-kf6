# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kdbusaddons-6.18.0.tar.xz"
SRC_URI[sha256sum] = "dce95cd146e18b400c4df31ea8c9bbba8f919e329a52dc1a19635184ac85e49a"

