# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/modemmanager-qt-6.18.0.tar.xz"
SRC_URI[sha256sum] = "c8c0c1c6d6c815efa11b8e31bbb3f5e8014789d7e0babfa1574280be6791d013"

