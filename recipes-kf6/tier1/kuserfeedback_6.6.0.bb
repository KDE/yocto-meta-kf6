# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kuserfeedback-6.6.0.tar.xz"
SRC_URI[sha256sum] = "3bb42251679edd643ccdccbc9babcae790b9d51b9dfaef6ded9b4ac34ad2df55"

