# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kconfig-6.2.0.tar.xz"
SRC_URI[sha256sum] = "2512bc036fc40cdc23345cbf8037853c7afdc93b7f81528547a451e0f8c429e9"

