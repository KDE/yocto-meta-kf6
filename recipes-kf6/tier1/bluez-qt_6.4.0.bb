# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/bluez-qt-6.4.0.tar.xz"
SRC_URI[sha256sum] = "d2d0aee9f42b501c00711565c2ebe87c608ae4c0786d901386fc55c65039b16b"

