# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/syntax-highlighting-6.10.0.tar.xz"
SRC_URI[sha256sum] = "b5b5e343ff27bc5c95be0051d5606dfcb3295f835830e7fc6dac8d2863891699"

