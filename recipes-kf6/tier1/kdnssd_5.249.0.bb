# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kdnssd-5.249.0.tar.xz"
SRC_URI[sha256sum] = "f11e106d351194e337ac4f02bb93357a711c45883b198e2a2338e5756bb96c83"

