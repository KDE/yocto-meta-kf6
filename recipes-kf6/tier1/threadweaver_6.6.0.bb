# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/threadweaver-6.6.0.tar.xz"
SRC_URI[sha256sum] = "19555488abf05a9d5a1641f165a67d347e23ab7d14c6f9464ffcf8db2370317a"

