# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kguiaddons-6.8.0.tar.xz"
SRC_URI[sha256sum] = "69ce69803c8d69bdbcd1becebd75bd496a9d1e9ea6e72d5c6f4a5cfda76a2386"

