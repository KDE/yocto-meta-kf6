# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/ki18n-6.3.0.tar.xz"
SRC_URI[sha256sum] = "4d95341eba2070fec3901396eb0a68f4a8423337de5ea23fb86b0ea70c957282"

