# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/breeze-icons-5.249.0.tar.xz"
SRC_URI[sha256sum] = "1cf0e3d849c22e226c4a473a8c403b6d0f1e7f90b89ca52560eaef5e2ced85b7"

