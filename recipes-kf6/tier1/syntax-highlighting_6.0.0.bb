# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/syntax-highlighting-6.0.0.tar.xz"
SRC_URI[sha256sum] = "2ef9e6b8aeb8543e64f4a3628afa331c0656fe6c485f3574c407651d7c12a653"

