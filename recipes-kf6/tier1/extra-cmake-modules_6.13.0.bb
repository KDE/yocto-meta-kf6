# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/extra-cmake-modules-6.13.0.tar.xz"
SRC_URI[sha256sum] = "7006017c00c817ff4c056995146d271791d1487a398d39ea6cac1cd59a8bf402"

