# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/extra-cmake-modules-6.0.0.tar.xz"
SRC_URI[sha256sum] = "23992bf19db717156b7d6dd13118caa79fd57f090beb062e8308db3c09f70d0c"

