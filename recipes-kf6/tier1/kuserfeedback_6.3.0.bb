# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kuserfeedback-6.3.0.tar.xz"
SRC_URI[sha256sum] = "3fe2ce37b92a70d604f38fa369b5fe2ea64e268c48aa450e9971fc8404e87006"

