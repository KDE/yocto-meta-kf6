# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kdbusaddons-5.249.0.tar.xz"
SRC_URI[sha256sum] = "2a3309f316f733172c6983d93579585e2a2d0b5eb049b0746120bf4472766644"

