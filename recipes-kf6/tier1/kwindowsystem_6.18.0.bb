# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kwindowsystem-6.18.0.tar.xz"
SRC_URI[sha256sum] = "a0a046039a11baebacd96d836e5765b981426f60d2cea9ff9a99ba8dbe56178e"

