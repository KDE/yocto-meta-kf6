# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kcodecs-6.13.0.tar.xz"
SRC_URI[sha256sum] = "dddde05d970d026ae6a2b31e3559532107f4de60f26d7d87a45733176e122082"

