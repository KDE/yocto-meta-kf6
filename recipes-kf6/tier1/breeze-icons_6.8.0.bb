# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/breeze-icons-6.8.0.tar.xz"
SRC_URI[sha256sum] = "75ee11fc441c27504e199e365693296edcd465f890db6aabcb0deca0ace22d3a"

