# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/sonnet-6.7.0.tar.xz"
SRC_URI[sha256sum] = "2f970d490effd668e64dd93ffef344a80db7e63130bb23df4fa0d6b14150e588"

