# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kwindowsystem-6.7.0.tar.xz"
SRC_URI[sha256sum] = "62c0f0b4a9507939d84aeeda55bbd4300b88c04e37953e5189b139003310a8f4"

