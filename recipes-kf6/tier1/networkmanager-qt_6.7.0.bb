# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/networkmanager-qt-6.7.0.tar.xz"
SRC_URI[sha256sum] = "563231644587918c950bcbe5fda0bf6a35e97a12f6b0e9bf9eaa4ce3141d3122"

