# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/solid-6.3.0.tar.xz"
SRC_URI[sha256sum] = "b821999599bcee01fd190dbd92f2cec31dae15eb05db51a5bc970c24b27d93d9"

