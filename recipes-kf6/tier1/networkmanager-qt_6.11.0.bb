# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/networkmanager-qt-6.11.0.tar.xz"
SRC_URI[sha256sum] = "e6e172324e4c978591299e2981ad6ae38e5d1e3d78db6ac83751604af202b60c"

