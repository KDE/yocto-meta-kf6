# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/modemmanager-qt-6.3.0.tar.xz"
SRC_URI[sha256sum] = "9cf3029746a8b8b3740bc4de93f138664325c7f4fe8017d92e342e7bc43ec7cf"

