# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/bluez-qt-5.249.0.tar.xz"
SRC_URI[sha256sum] = "f4c9996b162be5bcc403142a5bb96a830dcb0bdc5d52fc64996f4f767330edab"

