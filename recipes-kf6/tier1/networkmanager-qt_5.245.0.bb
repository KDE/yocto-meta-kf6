# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/networkmanager-qt-5.245.0.tar.xz"
SRC_URI[sha256sum] = "58b774f0a295d87a5a83d28f9270fcd57cac58962f362b5b693ad180cba64379"

