# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/ktexttemplate-6.1.0.tar.xz"
SRC_URI[sha256sum] = "2226f9472add196afd5b8b75b953a42d8249316437ed060d024462777e2df371"

