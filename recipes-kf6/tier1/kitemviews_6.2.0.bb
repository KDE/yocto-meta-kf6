# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kitemviews-6.2.0.tar.xz"
SRC_URI[sha256sum] = "7362d9893d1e9a863482573ecfc3abddd8c634512d8a1884f094a5f543af4a29"

