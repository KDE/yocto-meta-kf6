# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/modemmanager-qt-6.4.0.tar.xz"
SRC_URI[sha256sum] = "f2bc2aa916bce3ea58c38def984c35fada25e8756add400131782bfc62deee9d"

