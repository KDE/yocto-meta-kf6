# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kplotting-6.11.0.tar.xz"
SRC_URI[sha256sum] = "ceb915cc026cd20ff10e8fdb3e4914ea61f73686a2d9fe6a8839a5ead14a9892"

