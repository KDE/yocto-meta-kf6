# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kconfig-6.6.0.tar.xz"
SRC_URI[sha256sum] = "070bd019b07e15201e4c7072b71337c75f6917407406a1a7107fca1bff2855fe"

