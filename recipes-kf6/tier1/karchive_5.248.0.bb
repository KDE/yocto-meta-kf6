# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/karchive-5.248.0.tar.xz"
SRC_URI[sha256sum] = "1d30889f31354bf4a4e6b33664d439a023b97b59858648689567007feef9f92c"

