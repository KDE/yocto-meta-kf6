# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/prison-6.11.0.tar.xz"
SRC_URI[sha256sum] = "7cc8dff3ef172b24d10ee50c0876d79c87730b6fb23bd678708f7770b9da4f20"

