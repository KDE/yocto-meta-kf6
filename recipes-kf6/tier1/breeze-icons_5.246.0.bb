# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/breeze-icons-5.246.0.tar.xz"
SRC_URI[sha256sum] = "4d25fff07b53639189358f535a8f25012533f96685c615cb80eac9ab01ecd835"

