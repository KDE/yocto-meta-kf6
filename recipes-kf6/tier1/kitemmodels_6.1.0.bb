# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kitemmodels-6.1.0.tar.xz"
SRC_URI[sha256sum] = "5167d32af69bf00f6c9531c89513d54bffe16edd34a9e948efb49e9235e3e302"

