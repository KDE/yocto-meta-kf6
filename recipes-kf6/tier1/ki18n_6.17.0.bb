# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/ki18n-6.17.0.tar.xz"
SRC_URI[sha256sum] = "50f867d948c15aad91c3c57fe2f6462cdbf3881fab6fd99b85b15616f073983e"

