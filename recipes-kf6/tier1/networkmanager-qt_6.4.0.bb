# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/networkmanager-qt-6.4.0.tar.xz"
SRC_URI[sha256sum] = "3d2c905dd9c7445c44023ecf0646dd1b6fcdc83968f56dfa762296b0d15e9498"

