# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/attica-6.17.0.tar.xz"
SRC_URI[sha256sum] = "2fab4a2d32e98f62465b81bda6e416ff7fa99d6aa494c4b261f8772758f6b71a"

