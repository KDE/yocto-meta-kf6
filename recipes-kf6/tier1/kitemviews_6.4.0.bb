# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kitemviews-6.4.0.tar.xz"
SRC_URI[sha256sum] = "4280b9bcdc527979b364ed122d152e75951ff78fd801d46ccce2de6608d56440"

