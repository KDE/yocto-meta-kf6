# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kguiaddons-5.248.0.tar.xz"
SRC_URI[sha256sum] = "4c66f55e344036e3e31615da63c9251debaf99eac85335b315f41c750ef76a9c"

