# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/breeze-icons-6.13.0.tar.xz"
SRC_URI[sha256sum] = "76da054482c0b97e0ae68b94aaca9198c500288ded78b34bdb0b3cb88c473b5d"

