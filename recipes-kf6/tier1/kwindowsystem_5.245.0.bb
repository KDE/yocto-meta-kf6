# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kwindowsystem-5.245.0.tar.xz"
SRC_URI[sha256sum] = "8b9b58a4e7243c02797fccfcd90209eeff1bd02e82bef2f34f5c3b3cc5196db9"

