# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kplotting-6.4.0.tar.xz"
SRC_URI[sha256sum] = "4f9c770c814748f97a1d14e0ec9c452f2e406574fb51a85e71824ee81a71fc77"

