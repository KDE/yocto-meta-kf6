# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/modemmanager-qt-5.248.0.tar.xz"
SRC_URI[sha256sum] = "893b1c9ff3bebeca0baf7a04969a79dbe87ae6d87f97e2262a1311be0c7d981f"

