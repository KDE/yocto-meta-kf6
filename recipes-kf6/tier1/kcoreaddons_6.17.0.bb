# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kcoreaddons-6.17.0.tar.xz"
SRC_URI[sha256sum] = "0303d6d1e9e76cf9ec06a41acd1a52088a40df3a2805e97e1c327baf607842aa"

