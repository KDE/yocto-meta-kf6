# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kcodecs-5.245.0.tar.xz"
SRC_URI[sha256sum] = "9041a9349ac670d01c8acb26203b9669b3c651b565a73114a00a5b0639cf4eb0"

