# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kuserfeedback-5.248.0.tar.xz"
SRC_URI[sha256sum] = "ce9704073e4cb52a6dff274650a4ef5d8959ada1feb3126d7772d9e221da8c04"

