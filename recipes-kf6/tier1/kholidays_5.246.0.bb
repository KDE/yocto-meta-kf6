# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kholidays-5.246.0.tar.xz"
SRC_URI[sha256sum] = "34a2dbb5ac8a9891f8a512db6f8fd93d51a0b06b5d2f240d3dadad2270061359"

