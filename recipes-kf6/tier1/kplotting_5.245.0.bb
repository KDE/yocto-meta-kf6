# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kplotting-5.245.0.tar.xz"
SRC_URI[sha256sum] = "73ba9c654f1e2c2d22740beecf8c89f16718b8e139ac6b14917a972a230bab77"

