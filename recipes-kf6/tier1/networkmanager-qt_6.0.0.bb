# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/networkmanager-qt-6.0.0.tar.xz"
SRC_URI[sha256sum] = "225fc9f44e11d06687ce2ca56be7c7452f0ad2cc850b22f5715c8b701dabb700"

