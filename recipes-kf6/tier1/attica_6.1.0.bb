# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/attica-6.1.0.tar.xz"
SRC_URI[sha256sum] = "8b3dcac9a6753a9d0f780782c30f369ded3f531c478e95ca1c195384ad7db5a0"

