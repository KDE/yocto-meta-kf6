# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/syntax-highlighting-6.18.0.tar.xz"
SRC_URI[sha256sum] = "8be8057221a982c8d1fe42f95454fac9610eb51975226c6652689293cd335bfd"

