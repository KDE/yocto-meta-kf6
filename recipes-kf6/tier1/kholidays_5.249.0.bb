# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kholidays-5.249.0.tar.xz"
SRC_URI[sha256sum] = "4587ef13bb7e1c178ba7581b33eafab9aca86a199e6b890a2b3cac6e101a180c"

