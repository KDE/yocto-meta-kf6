# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/solid-6.17.0.tar.xz"
SRC_URI[sha256sum] = "17f0510ef134b66e647ee217b64870532d757c721c815f20c49567b979c9c725"

