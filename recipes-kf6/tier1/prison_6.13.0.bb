# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/prison-6.13.0.tar.xz"
SRC_URI[sha256sum] = "23c46e289c27f1dacb0c83117abdc621b5c0bfeab45cd187464b0068f70003e1"

