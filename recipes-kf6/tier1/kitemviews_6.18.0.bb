# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kitemviews-6.18.0.tar.xz"
SRC_URI[sha256sum] = "f74c03e2ec367238ec395b1f2438878999c2be3e29b41b6bd4a3ccd04440e29a"

