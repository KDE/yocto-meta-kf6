# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/prison-6.3.0.tar.xz"
SRC_URI[sha256sum] = "769807725787051e5e9a2f41eb7f791a9ce11be775a7eeff8d525f2a78b4bc46"

