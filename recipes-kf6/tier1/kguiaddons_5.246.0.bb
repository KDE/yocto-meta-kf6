# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kguiaddons-5.246.0.tar.xz"
SRC_URI[sha256sum] = "756cbaae2ee8378f5e6079a7578d075124ac57c5e903abba10a96efde3b1faa7"

