# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kidletime-6.10.0.tar.xz"
SRC_URI[sha256sum] = "fa25fe866aefd4536022142822ce9856f7a85ffa95070980527de9b31eab0988"

