# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/breeze-icons-6.3.0.tar.xz"
SRC_URI[sha256sum] = "67266378f2d7dbf13dc4f691de43f30b5aca4e4a3336e9f60f0efba2a474e626"

