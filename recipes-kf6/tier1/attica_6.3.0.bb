# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/attica-6.3.0.tar.xz"
SRC_URI[sha256sum] = "abaf3a113a002d5d8435a3a75020f98c574290d2c552a5f256291d0418cc59ed"

