# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/threadweaver-6.13.0.tar.xz"
SRC_URI[sha256sum] = "64a162f49fd25263dd992b3e70854b7a7b3bcd15114bb67095bb513c4097e39a"

