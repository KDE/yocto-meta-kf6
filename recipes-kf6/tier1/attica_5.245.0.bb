# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/attica-5.245.0.tar.xz"
SRC_URI[sha256sum] = "7ec89bc91b069febf01ec385c412a4f837b264e7d14615802a2d848e94620c2d"

