# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/ktexttemplate-6.7.0.tar.xz"
SRC_URI[sha256sum] = "d6b75f193f4d8d817cf374872a57427489c61736121c72a69c4dd7ee62e1e233"

