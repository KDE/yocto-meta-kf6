# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kcodecs-6.8.0.tar.xz"
SRC_URI[sha256sum] = "96c9535c6f79571cd7170360dc0b64a33d529d59cbd9457934bfc0cf6cf4b27f"

