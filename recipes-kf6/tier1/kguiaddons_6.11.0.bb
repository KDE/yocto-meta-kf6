# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kguiaddons-6.11.0.tar.xz"
SRC_URI[sha256sum] = "ef0925f609ae5b62ed689451dfe9937719ce4ec26714952b5496e3e128d5cc5c"

