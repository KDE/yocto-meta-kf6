# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/modemmanager-qt-5.246.0.tar.xz"
SRC_URI[sha256sum] = "8ef5e84356e4d0879a24f0914a63cbabc16d9232e638f191f3a287cf1953cf27"

