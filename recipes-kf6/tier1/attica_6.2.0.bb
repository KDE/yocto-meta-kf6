# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/attica-6.2.0.tar.xz"
SRC_URI[sha256sum] = "275fb00b3f483704d800484883a3789797a3198b0ce680d85313d9977ffde2f0"

