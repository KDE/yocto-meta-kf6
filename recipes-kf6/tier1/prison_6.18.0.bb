# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/prison-6.18.0.tar.xz"
SRC_URI[sha256sum] = "38a4f154b39b4d2e4b86d16f84846039d27bd70cb26ecd488b591f612dd4141e"

