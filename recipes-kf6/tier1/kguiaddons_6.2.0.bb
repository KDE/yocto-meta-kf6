# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kguiaddons-6.2.0.tar.xz"
SRC_URI[sha256sum] = "ba5a5e42d5b9b94486419263836074429fd3facfc364fd4e3a29a54bc6de5ddb"

