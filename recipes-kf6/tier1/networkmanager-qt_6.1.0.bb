# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/networkmanager-qt-6.1.0.tar.xz"
SRC_URI[sha256sum] = "6e4979b5f889afcff4f8c7417e283c1db9e4df36ca0628bb3ebef09b62abd302"

