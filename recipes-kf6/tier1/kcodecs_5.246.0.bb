# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kcodecs-5.246.0.tar.xz"
SRC_URI[sha256sum] = "a65678dde05f20490b868c4cdd29308cebce26d2fe2ba9a1b9800ee665897d6c"

