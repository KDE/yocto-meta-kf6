# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kdnssd-6.7.0.tar.xz"
SRC_URI[sha256sum] = "e9140475fc6e4ee1e0fe39a21816a3c003fcb1092222079f422fd02ad2a902a1"

