# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kirigami-5.245.0.tar.xz"
SRC_URI[sha256sum] = "7f3d175347bf50e904821d910e160a12d2d4e577c84b8aaf193fdc284c3c83fc"

