# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kidletime-6.1.0.tar.xz"
SRC_URI[sha256sum] = "c8d85c129fd2e9520bec3aa9670449b4ea2cf092060a54fdb24cba63475faf3a"

