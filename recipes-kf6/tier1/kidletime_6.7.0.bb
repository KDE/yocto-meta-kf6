# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kidletime-6.7.0.tar.xz"
SRC_URI[sha256sum] = "60a6c70387b63e61147029ce57f170237271411630a3372a0e8d7240b8006aaf"

