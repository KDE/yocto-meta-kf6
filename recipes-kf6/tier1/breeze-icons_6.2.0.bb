# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/breeze-icons-6.2.0.tar.xz"
SRC_URI[sha256sum] = "df5a3b150768dd5c781a6c3d1848d79f4b0eb2f327e248c5426a1234aa4c135b"

