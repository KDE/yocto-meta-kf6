# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kwidgetsaddons-6.6.0.tar.xz"
SRC_URI[sha256sum] = "137cc549d62f9bc9a147d8281d616f4415fc5ac3541d48e66c5cb798e7111fc3"

