# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kirigami-5.249.0.tar.xz"
SRC_URI[sha256sum] = "0154e7cbd2d6b40cf54720401d333ae3ba1c7aab12bbd2ad2060a12b78e07855"

