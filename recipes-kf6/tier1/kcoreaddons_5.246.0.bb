# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kcoreaddons-5.246.0.tar.xz"
SRC_URI[sha256sum] = "4c1ab9bd5ef59e7b263a99575b1f3405e91a8d4a8714fe6c6b7cca64273945df"

