# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/attica-6.7.0.tar.xz"
SRC_URI[sha256sum] = "daa5c07b474899e16b42710e03d0590936bce0f54800239d633d48caa3be0d7d"

