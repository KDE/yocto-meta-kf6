# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/threadweaver-6.2.0.tar.xz"
SRC_URI[sha256sum] = "e74de2df0bb50148acc8a6161f9809991ae4b2334b58a9ee092ba1d827044337"

