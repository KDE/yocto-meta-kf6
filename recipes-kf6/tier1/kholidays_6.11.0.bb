# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kholidays-6.11.0.tar.xz"
SRC_URI[sha256sum] = "ccdbfab5eafc043574900d66e0022326f6048e7dcdb09bc538dedea99889c6af"

