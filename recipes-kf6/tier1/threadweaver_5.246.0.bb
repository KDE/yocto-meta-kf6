# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/threadweaver-5.246.0.tar.xz"
SRC_URI[sha256sum] = "a79ff73d38644aba48185834061f66e5de8dc7cfe4a8399bd87aea61b3ee3430"

