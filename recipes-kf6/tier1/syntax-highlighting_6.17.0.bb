# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/syntax-highlighting-6.17.0.tar.xz"
SRC_URI[sha256sum] = "3d16bec0fbeb853be684c35f47550d59814db1f4b707ec77b862f3650f353fcc"

