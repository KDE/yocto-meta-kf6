# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kcoreaddons-6.6.0.tar.xz"
SRC_URI[sha256sum] = "5aba9abf934e2daf5f70837cbac088607fe8bd505e172c4af6cdaacdda25c50b"

