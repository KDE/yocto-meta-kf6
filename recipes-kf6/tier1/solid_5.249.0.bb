# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/solid-5.249.0.tar.xz"
SRC_URI[sha256sum] = "bf995c9fedaba517b469a7e49fc53a90f3bfb2a7b0b5204ab58e95a871305548"

