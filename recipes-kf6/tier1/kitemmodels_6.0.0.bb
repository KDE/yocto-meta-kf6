# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kitemmodels-6.0.0.tar.xz"
SRC_URI[sha256sum] = "89b879981722821a911bba1765128820217944fa78e5452369158ed97a835b3a"

