# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/sonnet-6.2.0.tar.xz"
SRC_URI[sha256sum] = "84e712ad56bc94ff8efc9bddfab41f6c327121b3ddd69030e940acc9133627ed"

