# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kitemmodels-6.2.0.tar.xz"
SRC_URI[sha256sum] = "c066888313260d75a207939334b056b4014ba7364b437325561790eb7b3742ba"

