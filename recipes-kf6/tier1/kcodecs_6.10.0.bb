# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kcodecs-6.10.0.tar.xz"
SRC_URI[sha256sum] = "96183ffbb18502cd67b6fc78ac286e233ef46ee0d713ee1df2cb4c138f2141a0"

