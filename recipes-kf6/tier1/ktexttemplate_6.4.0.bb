# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/ktexttemplate-6.4.0.tar.xz"
SRC_URI[sha256sum] = "74300fe80fd7d0e8724b381d8f885345d91f47ae341003d4655e82b0dab6bf90"

