# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kholidays-6.4.0.tar.xz"
SRC_URI[sha256sum] = "1200fab6bd1546f016688597eef6c10c948f999d4eeab1e8eaaca345ccd2adcd"

