# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kguiaddons-5.249.0.tar.xz"
SRC_URI[sha256sum] = "6f21b46268f148a74636b9363e269d17e3bb7de01211905810f07688caa69563"

