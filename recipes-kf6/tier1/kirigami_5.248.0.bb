# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kirigami-5.248.0.tar.xz"
SRC_URI[sha256sum] = "2bed2aacd5427cae37164b7cc1f47c17bd238eeadc4272aa47b84d4a5ff66bfd"

