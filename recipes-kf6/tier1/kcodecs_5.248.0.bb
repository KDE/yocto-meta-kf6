# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kcodecs-5.248.0.tar.xz"
SRC_URI[sha256sum] = "36d7d5a3d8509c37230fd9693e024123b46f5786a330100c371b44ace47cee83"

