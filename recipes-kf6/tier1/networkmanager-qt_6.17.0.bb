# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/networkmanager-qt-6.17.0.tar.xz"
SRC_URI[sha256sum] = "d83beae867fb7d669886f513893f8eec58b5d7a24b429d89dc5c6c08b7a3f4e0"

