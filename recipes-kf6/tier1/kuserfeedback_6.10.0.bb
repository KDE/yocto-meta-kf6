# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kuserfeedback-6.10.0.tar.xz"
SRC_URI[sha256sum] = "5dd17da7169a9a90c82757536c667d748d1909985b979bb1e2e51da84a07372f"

