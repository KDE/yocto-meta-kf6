# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kwidgetsaddons-6.4.1.tar.xz"
SRC_URI[sha256sum] = "d35d2198ff1a4581e7d7339d5b4212e5ecf05c485e2340be20ba84260f28f23b"

