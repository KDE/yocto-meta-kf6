# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kquickcharts-6.18.0.tar.xz"
SRC_URI[sha256sum] = "941ead378d02e0581b706639c7cf474339818f6cd48d918646782f71bc7f74cb"

