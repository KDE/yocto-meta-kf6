# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kcalendarcore-6.3.0.tar.xz"
SRC_URI[sha256sum] = "cddf76b604cb5e26320781f76ca0caba8e23e653263d2a2095e91b288a1613fb"

