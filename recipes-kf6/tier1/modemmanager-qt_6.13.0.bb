# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/modemmanager-qt-6.13.0.tar.xz"
SRC_URI[sha256sum] = "25efd332c16af8f58dc335e8c259ec3c13b3e5e9f4c2aeadb87eca562d34dbd0"

