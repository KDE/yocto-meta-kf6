# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kquickcharts-6.0.0.tar.xz"
SRC_URI[sha256sum] = "ebd9a8f501b80e72a12f50d984847a698f7283be389644f7e24133484076a6a5"

