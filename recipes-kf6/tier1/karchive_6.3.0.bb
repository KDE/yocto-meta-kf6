# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/karchive-6.3.0.tar.xz"
SRC_URI[sha256sum] = "27807f5707668f9aa41c898eba90198a3083577fdab9f4751a02fefe63674e29"

