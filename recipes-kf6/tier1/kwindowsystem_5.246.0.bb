# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kwindowsystem-5.246.0.tar.xz"
SRC_URI[sha256sum] = "f3534313669daccee628614467e8ef33f9436016db7e2d5818f5bfa071f2b52a"

