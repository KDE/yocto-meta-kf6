# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kidletime-5.249.0.tar.xz"
SRC_URI[sha256sum] = "8ebb9f7ca9568a03bbe919cd560faa0a77a711a2b2cead027daf9c5b6e4adf1c"

