# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/karchive-5.249.0.tar.xz"
SRC_URI[sha256sum] = "df3c9258b8c0cb0a984d7132033534e9c864bf83c5872c09dad62b742d47d0c7"

