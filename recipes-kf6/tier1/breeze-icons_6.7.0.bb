# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/breeze-icons-6.7.0.tar.xz"
SRC_URI[sha256sum] = "39037e3fcbbb7a65011685c498cae31ff496a5f2493269c955bb29c94a688b74"

