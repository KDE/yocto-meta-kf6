# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/modemmanager-qt-6.6.0.tar.xz"
SRC_URI[sha256sum] = "e8cff8728c83e3638aa85d2f837ca75e1c50325632f4b64e5e4185d0cd6b071b"

