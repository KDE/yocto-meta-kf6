# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/sonnet-6.6.0.tar.xz"
SRC_URI[sha256sum] = "2f8a5ef2d5264a31af686efa8fe31372837edc5317f3103395dd389c37237316"

