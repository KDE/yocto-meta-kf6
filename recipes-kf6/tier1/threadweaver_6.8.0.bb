# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/threadweaver-6.8.0.tar.xz"
SRC_URI[sha256sum] = "8864dd30b7a55f751c1ba81abda789a3934964be18ba1c8e694e2bc48768bfde"

