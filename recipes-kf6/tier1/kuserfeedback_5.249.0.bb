# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kuserfeedback-5.249.0.tar.xz"
SRC_URI[sha256sum] = "cb4e3d63a46bc52e627d0fd1351d05876a13ab34e2a1e542dffa8c70db4cf739"

