# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kitemviews-6.13.0.tar.xz"
SRC_URI[sha256sum] = "e0de8c9fa2baa27bde6abd3847b6d5f4cb54aeceab3436c64f89a50fe1d9695d"

