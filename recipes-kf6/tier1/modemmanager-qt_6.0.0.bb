# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/modemmanager-qt-6.0.0.tar.xz"
SRC_URI[sha256sum] = "efd6ea3eae52b21279bdee38e80f667c35d98b977a442f4bd6b8a0a471f90ff3"

