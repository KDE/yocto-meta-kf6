# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kitemviews-5.249.0.tar.xz"
SRC_URI[sha256sum] = "5317bc6fd37318f8a70209308646952cc934fde67bc7030586498d64fefed6d0"

