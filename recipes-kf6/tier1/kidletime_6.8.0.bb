# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kidletime-6.8.0.tar.xz"
SRC_URI[sha256sum] = "51016058faf392515ea7f582d25c666abddf38ef66abf187502cf46c5e11e410"

