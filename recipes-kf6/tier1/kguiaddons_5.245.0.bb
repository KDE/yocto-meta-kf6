# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kguiaddons-5.245.0.tar.xz"
SRC_URI[sha256sum] = "567e4d3f43e103887de748420d67a7fe6b2729ff42af142ae847d2c2b4c9c527"

