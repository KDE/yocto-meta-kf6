# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kglobalaccel-6.7.0.tar.xz"
SRC_URI[sha256sum] = "2a35b9e06c6601d602b3a45e278c49e11e4627939cfacffb1fdee0826a6f6e0b"

