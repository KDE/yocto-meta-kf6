# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/attica-6.0.0.tar.xz"
SRC_URI[sha256sum] = "ef21d8e57aeae4757b6b40dfe0d0e9c38302a979164b4e4d493b631b7c023d23"

