# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kuserfeedback-5.246.0.tar.xz"
SRC_URI[sha256sum] = "a222f2b2cadbb3ab3f8dbee3399b407c86b45a2a5ba01f7aa1103bfed37e5ae7"

