# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kquickcharts-5.246.0.tar.xz"
SRC_URI[sha256sum] = "8c33c0a5f29206c74afb3b7fd58bedfc2e57ee978e76f24ef3e342aa74a5d21d"

