# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kconfig-6.13.0.tar.xz"
SRC_URI[sha256sum] = "2ec66c996288df472fcc3aba50540e266fb6218d60d38e7a4a445d4b193f9445"

