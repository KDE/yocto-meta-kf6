# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/bluez-qt-5.245.0.tar.xz"
SRC_URI[sha256sum] = "7e65c260b4908463f108b1872aa6666c80e528f60f83201c8c469013020af299"

