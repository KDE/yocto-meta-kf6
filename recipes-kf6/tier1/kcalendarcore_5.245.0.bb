# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kcalendarcore-5.245.0.tar.xz"
SRC_URI[sha256sum] = "0cc437d22b319c28a1cc85823c016870caf35c000f065242512ee452893954e2"

