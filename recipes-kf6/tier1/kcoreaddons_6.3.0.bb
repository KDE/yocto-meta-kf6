# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kcoreaddons-6.3.0.tar.xz"
SRC_URI[sha256sum] = "b8bb93bac2a1175ff60583f6fca14b8707eb878eefe074121741b3c85cc5c756"

