# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kconfig-5.246.0.tar.xz"
SRC_URI[sha256sum] = "e86348458005a932f0c61f7f3fc5400765b8b150fe4cf8d83ec157a96cbd0076"

