# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/bluez-qt-6.17.0.tar.xz"
SRC_URI[sha256sum] = "736e6b0c315897c5ea844544feeef52fd1e9948ec4ff24f2c52c5fd718a0e65d"

