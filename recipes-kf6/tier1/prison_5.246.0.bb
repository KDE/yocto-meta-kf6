# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/prison-5.246.0.tar.xz"
SRC_URI[sha256sum] = "434cdf931446b3bf0802eaeacd8a6e7c20a054ff7243ecfb0edff8e32323e3e9"

