# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kitemmodels-6.11.0.tar.xz"
SRC_URI[sha256sum] = "398dc4e3c5c44461350a20ac234055bafc2b184284ddea91563134ef62f5d6a6"

