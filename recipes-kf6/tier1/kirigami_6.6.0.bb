# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kirigami-6.6.0.tar.xz"
SRC_URI[sha256sum] = "9809cce703dfa8afe2c64e196f90c035850e2e432a9bd90ce32a40865368a7fe"

