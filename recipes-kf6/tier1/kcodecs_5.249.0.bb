# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kcodecs-5.249.0.tar.xz"
SRC_URI[sha256sum] = "b9a08ad581626b9a34bd8f4a199f450273467e4794a08f74f866009375b535ce"

