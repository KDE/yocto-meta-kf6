# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kirigami-6.18.0.tar.xz"
SRC_URI[sha256sum] = "e0574bf5f530a7cd98e0342498681f4374beff108e74262063b105e1c977f866"

