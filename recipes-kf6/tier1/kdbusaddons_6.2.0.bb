# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kdbusaddons-6.2.0.tar.xz"
SRC_URI[sha256sum] = "bca0df3fc7361effcf81ffb795d8ff62e2189ea9672492d6b26c1e0144fedd67"

