# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kidletime-6.0.0.tar.xz"
SRC_URI[sha256sum] = "aa846b4cfcbc48d084350d1f525638fcf4766b0363bcde40fcefa88a8fbda7b3"

