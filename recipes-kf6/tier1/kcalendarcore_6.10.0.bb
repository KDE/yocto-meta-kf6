# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kcalendarcore-6.10.0.tar.xz"
SRC_URI[sha256sum] = "988f2fd648341967384d95d3d12bb936a8a7737a931e72c2b5616050bc30336a"

