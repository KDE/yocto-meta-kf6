# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kdbusaddons-6.13.0.tar.xz"
SRC_URI[sha256sum] = "9b2f16045a38b0db14d1946a3df552aed45edac981e5bff69fc9752abcb17f9e"

