# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/syntax-highlighting-5.246.0.tar.xz"
SRC_URI[sha256sum] = "3550f626b83d60d31f2bab1df590777aec8a2e1adb2428344293927a3c173920"

