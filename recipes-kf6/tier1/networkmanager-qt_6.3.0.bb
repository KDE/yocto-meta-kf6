# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/networkmanager-qt-6.3.0.tar.xz"
SRC_URI[sha256sum] = "0ca96a3bf78f033a36be59c75d3d6382b4ef13e753419eed13ef2e33821e39e0"

