# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/networkmanager-qt-6.8.0.tar.xz"
SRC_URI[sha256sum] = "15879251ef1a5e88465b78f8f59e2be3d1f29694c5c9151fa0d542ea78949767"

