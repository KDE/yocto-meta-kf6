# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kcalendarcore-6.1.0.tar.xz"
SRC_URI[sha256sum] = "1cffef32a4076b79c26705e12043fcb76cbbfcaef8c120ef40b858cc44a2139b"

