# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kholidays-5.245.0.tar.xz"
SRC_URI[sha256sum] = "a737a52717e9e0514358fdd3384117c51cb4153fb99135d28eb6a4fbda1b12d5"

