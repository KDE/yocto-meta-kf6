# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kquickcharts-6.7.0.tar.xz"
SRC_URI[sha256sum] = "664047e7b622c0b865d7466817179455fb3851cbb15a8f2c38b8ab9cf85098a4"

