# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/syntax-highlighting-5.249.0.tar.xz"
SRC_URI[sha256sum] = "519e6d59392434f82bbcedd7ede916494c8c49f8080b5b6708c102c474af0a49"

