# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kidletime-5.246.0.tar.xz"
SRC_URI[sha256sum] = "d81772726e221157c2bd84e6d39890da96e43401e91cf5d1cc7e51b2d6cfe51c"

