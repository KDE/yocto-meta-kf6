# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/bluez-qt-6.10.0.tar.xz"
SRC_URI[sha256sum] = "62a47b7705625d6eba82d264f5fa42820fffafc8def65c9cd00640b4737c822d"

