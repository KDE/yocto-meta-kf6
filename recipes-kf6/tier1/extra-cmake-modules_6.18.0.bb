# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/extra-cmake-modules-6.18.0.tar.xz"
SRC_URI[sha256sum] = "b2d2222cfe5ace502c60bd8a77a79bc0230f48cee83265c89dcc2618b960e293"

