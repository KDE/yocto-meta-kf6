# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/bluez-qt-6.2.0.tar.xz"
SRC_URI[sha256sum] = "964874f4e4b4cfa63a940cbd0ac21bd0dc4fc06c14ff7a8db54f98119bf8b430"

