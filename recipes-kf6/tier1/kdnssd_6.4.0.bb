# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kdnssd-6.4.0.tar.xz"
SRC_URI[sha256sum] = "0bc639a41b3beedecd0900caa757ff864e29357e3582f9150092be0e5558cc12"

