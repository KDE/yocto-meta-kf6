# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kwindowsystem-5.249.0.tar.xz"
SRC_URI[sha256sum] = "cc5e62380e1ef354a3088ddeb1db93d0e018e47e9ec0869a4b493ab737e81508"

