# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kplotting-6.6.0.tar.xz"
SRC_URI[sha256sum] = "9275dd99cedb4fd53a00945e44ed694b5a27ada41604b2a54b2bcc5b4e2a3f79"

