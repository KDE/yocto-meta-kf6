# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kconfig-6.17.0.tar.xz"
SRC_URI[sha256sum] = "067435b24ca9f7cf56a8ce5b108438a15607b26dc52905ae07dc187c7e2949de"

