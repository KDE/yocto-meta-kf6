# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kirigami-6.2.1.tar.xz"
SRC_URI[sha256sum] = "910412770e79b9c13ddac42199fa7511770cd9485b8f5a264e1ef6363a330c99"

