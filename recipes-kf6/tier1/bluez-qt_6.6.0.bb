# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/bluez-qt-6.6.0.tar.xz"
SRC_URI[sha256sum] = "1a2a805ba12639c1784d2f549f5e98f210fc8d1878c5ca770936eac827c8eb00"

