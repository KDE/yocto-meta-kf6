# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/karchive-5.245.0.tar.xz"
SRC_URI[sha256sum] = "7097fc0e45295b9b95874a78866624e6b2cdcfceb64ed75e0839ce8715bf9697"

