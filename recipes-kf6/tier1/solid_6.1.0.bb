# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/solid-6.1.0.tar.xz"
SRC_URI[sha256sum] = "074a984b58ef51017ee767548bfce0ca00bb710e88a4ab00bc9020a46cfa4262"

