# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kwindowsystem-5.248.0.tar.xz"
SRC_URI[sha256sum] = "b7b3b7793e4053d7c0b02b3c56e04001d8a82541d0ae34269d73ef7067b700cb"

