# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/syntax-highlighting-5.248.0.tar.xz"
SRC_URI[sha256sum] = "79a0933070528c070064a395e5238d1bee03d65b6f07ec58a55fccd2d92ae8bb"

