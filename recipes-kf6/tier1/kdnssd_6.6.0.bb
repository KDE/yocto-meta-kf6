# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kdnssd-6.6.0.tar.xz"
SRC_URI[sha256sum] = "3743ea3f156358d6945df69e67c98c69f438413620c6ac7286d0427342157fc7"

