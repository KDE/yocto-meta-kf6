# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kdbusaddons-6.3.0.tar.xz"
SRC_URI[sha256sum] = "7e2d8999ef09513aaa42000acb5369b203cd5977308f6e7891cde6a8d4422002"

