# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/karchive-6.0.0.tar.xz"
SRC_URI[sha256sum] = "75a591d9648026eb86826974e6f3882e7f620592ecef8fabeb19206e63b04e50"

