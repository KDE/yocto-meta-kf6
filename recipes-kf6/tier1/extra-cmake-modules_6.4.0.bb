# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/extra-cmake-modules-6.4.0.tar.xz"
SRC_URI[sha256sum] = "ced3f20741ddad24185dc1280a0c0d9171ba2508f84762417d74808561295add"

