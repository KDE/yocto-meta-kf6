# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/ki18n-5.248.0.tar.xz"
SRC_URI[sha256sum] = "06391ef39e048a6dd26e90a3d2a5c849be0dc95999a3e044bbabc4651976c69c"

