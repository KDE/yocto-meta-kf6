# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/bluez-qt-6.1.0.tar.xz"
SRC_URI[sha256sum] = "f9424ef15e07f8174f06911af4616a06dd88addda975f954f96eaaa871cd8ebb"

