# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kdnssd-5.246.0.tar.xz"
SRC_URI[sha256sum] = "0789adbda03888a3ba796fa0aa66fac6d08d9f4290c931baa5d5b8e4449c8076"

