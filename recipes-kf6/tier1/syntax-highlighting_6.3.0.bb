# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/syntax-highlighting-6.3.0.tar.xz"
SRC_URI[sha256sum] = "38300a35c969bef5fa36b437d54342da0a0c805282a657519bd4e2f7b42df984"

