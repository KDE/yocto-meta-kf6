# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kdnssd-6.8.0.tar.xz"
SRC_URI[sha256sum] = "49d9ac911ac6412170b330c83142044610ae90f571c60318b22e197e2898973e"

