# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/breeze-icons-6.0.0.tar.xz"
SRC_URI[sha256sum] = "473e9851e4f84a64f1e808d58fd8760219a1b08feaf4b514a1399c8e5c889dc4"

