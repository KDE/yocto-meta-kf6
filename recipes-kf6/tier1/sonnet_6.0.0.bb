# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/sonnet-6.0.0.tar.xz"
SRC_URI[sha256sum] = "2083df45e7a729a37a8d6642145e6acf4c53e6b235303843e31031c8d290ae8b"

