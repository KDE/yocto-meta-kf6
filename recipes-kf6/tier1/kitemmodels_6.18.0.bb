# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kitemmodels-6.18.0.tar.xz"
SRC_URI[sha256sum] = "887653b1571ad0afd4b836ad2451a42b07657d0eede1a2628e9c69102ce23de1"

