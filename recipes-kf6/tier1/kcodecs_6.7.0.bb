# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kcodecs-6.7.0.tar.xz"
SRC_URI[sha256sum] = "9ab494055e06bdce45568b7c47edb2aa9ecaa9dec0c0fb152367b4321921b9f2"

