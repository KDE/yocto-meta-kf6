# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kdnssd-5.245.0.tar.xz"
SRC_URI[sha256sum] = "616632ae076ef6f16eaa7e9d8f3400f0180b70e6d7e489ec04b2adc271d80e4b"

