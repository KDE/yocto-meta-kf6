# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/modemmanager-qt-5.245.0.tar.xz"
SRC_URI[sha256sum] = "d2008ccfc8ed14b0caf472fab8793cb72304dbfe73fd47554d4b5adb4a4c212c"

