# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kquickcharts-6.11.0.tar.xz"
SRC_URI[sha256sum] = "ffc35a7b0dde52acdae508925a555b76006cc9d4b78eb003e9a31cd439f2993f"

