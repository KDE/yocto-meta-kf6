# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kconfig-6.3.0.tar.xz"
SRC_URI[sha256sum] = "8d809aaf7b5151ecd797c601c7f2701bc426b66d431b52069c7ff3b4002d7979"

