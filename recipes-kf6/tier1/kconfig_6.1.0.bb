# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kconfig-6.1.0.tar.xz"
SRC_URI[sha256sum] = "2fda5f25beac5260a70f3f629144b5c229bf352cae208893ed44a9732c6dcaf7"

