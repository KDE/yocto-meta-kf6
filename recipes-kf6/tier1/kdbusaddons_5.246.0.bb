# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kdbusaddons-5.246.0.tar.xz"
SRC_URI[sha256sum] = "68d6743bad641bd1ea0ec815adc4f8913df5f55e95e78aef39cdd96640ebbd61"

