# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kcoreaddons-6.18.0.tar.xz"
SRC_URI[sha256sum] = "e1d03cfc7d45987ec31f31104f4732812980e0038beab222633da1108eb6f42f"

