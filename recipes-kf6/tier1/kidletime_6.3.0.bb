# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kidletime-6.3.0.tar.xz"
SRC_URI[sha256sum] = "cd8f677cce6738342b88817d0e7c1803460f00e409d730c5ae0ea33b1426472d"

