# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kglobalaccel-6.0.0.tar.xz"
SRC_URI[sha256sum] = "58009eb0d0b70c93dc0cb0886ae929f3756e972c841d7a3e465df8307e5b7149"

