# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/attica-5.246.0.tar.xz"
SRC_URI[sha256sum] = "cb6978c0f927f9d12753bceade14d456cc1dcc35998b64a73780f85b419caf0e"

