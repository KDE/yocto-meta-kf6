# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kcodecs-6.6.0.tar.xz"
SRC_URI[sha256sum] = "d9dc2e3294aa32684990bde01bb88dedb2610a28d7c1d62a178a393fa566123b"

