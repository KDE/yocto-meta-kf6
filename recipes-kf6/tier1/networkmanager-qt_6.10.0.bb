# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/networkmanager-qt-6.10.0.tar.xz"
SRC_URI[sha256sum] = "2f437ab6b534fb7dcde6ed40ebdc2c1680532f742b8e326ea68a47ae58173191"

