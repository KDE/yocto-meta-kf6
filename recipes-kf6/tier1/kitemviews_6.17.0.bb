# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kitemviews-6.17.0.tar.xz"
SRC_URI[sha256sum] = "31d1c8ff64b28eef216e63a443accdc621c53f51ec23e6a137d9e08629742fd1"

