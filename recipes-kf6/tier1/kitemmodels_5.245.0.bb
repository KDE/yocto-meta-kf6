# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kitemmodels-5.245.0.tar.xz"
SRC_URI[sha256sum] = "0db7491d284d687fd360069d82ec3bc719e1ca9bb168cf89b9de6235b1a68009"

