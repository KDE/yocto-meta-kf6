# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kplotting-6.0.0.tar.xz"
SRC_URI[sha256sum] = "dc43644b7632344bd413d754aa7dd1052a3cde9230193abf5da47de1341a63ff"

