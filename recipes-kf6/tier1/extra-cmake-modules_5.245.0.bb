# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/extra-cmake-modules-5.245.0.tar.xz"
SRC_URI[sha256sum] = "f18133e1ea0aa841aaf3bfcedaa792cf524670908df0dbd350ea92b28010fe3e"

