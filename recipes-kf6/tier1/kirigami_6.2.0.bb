# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kirigami-6.2.0.tar.xz"
SRC_URI[sha256sum] = "57245b518d64c46afab42a1a619609afb60e546033a162b718c752b88350b40c"

