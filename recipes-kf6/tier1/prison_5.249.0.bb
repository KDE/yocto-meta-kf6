# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/prison-5.249.0.tar.xz"
SRC_URI[sha256sum] = "4aa3259f8237047fe9002fc649cfc4a5cca641459ace18f776434701d8613367"

