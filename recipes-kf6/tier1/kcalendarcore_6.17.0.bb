# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kcalendarcore-6.17.0.tar.xz"
SRC_URI[sha256sum] = "4a0675c6211caf183a067194b24093dc63015a1a59be07b864cf45f7acd18e13"

