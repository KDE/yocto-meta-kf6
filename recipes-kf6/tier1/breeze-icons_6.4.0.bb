# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/breeze-icons-6.4.0.tar.xz"
SRC_URI[sha256sum] = "6b6c0c82e1bda2023aeeae235976522a4209ef76181928b052948a76be1f1a00"

