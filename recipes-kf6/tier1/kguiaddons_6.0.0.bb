# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kguiaddons-6.0.0.tar.xz"
SRC_URI[sha256sum] = "20af58ab639ea99df09acbd74af0c867f22f1d9f91595623ab44fba5834eaa62"

