# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kholidays-5.248.0.tar.xz"
SRC_URI[sha256sum] = "47f99d5ba4fdc31417b9fd7824d74e0e84c7b8b114028d77998d1d4c929e3c26"

