# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kwidgetsaddons-5.249.0.tar.xz"
SRC_URI[sha256sum] = "db1d838d63843b66483b023f16be0a1c70fda45261448a38a6a748387c5288b0"

