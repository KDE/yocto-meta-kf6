# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/karchive-6.6.0.tar.xz"
SRC_URI[sha256sum] = "51e9d21cb87e2241bca6a69e1496661d05d00a581107bfcf9859aa9e70acac1b"

