# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kitemviews-6.1.0.tar.xz"
SRC_URI[sha256sum] = "e9e86c2aa49278c38959b1804fe1c6c2057f3e9be896091f898fb81692b20a4d"

