# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kcalendarcore-6.8.0.tar.xz"
SRC_URI[sha256sum] = "cc5fc3c304b117470744689829e94baf85c6ce4dc24593b9958f1de899c87412"

