# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kwindowsystem-6.4.0.tar.xz"
SRC_URI[sha256sum] = "c4e8742cbdd294d56a689d66a73b03a660702037ac46242f17cc01b24f014a59"

