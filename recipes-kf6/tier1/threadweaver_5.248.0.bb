# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/threadweaver-5.248.0.tar.xz"
SRC_URI[sha256sum] = "6b35957bb5fd722832dd57e9a2193bc3b1b6d0a1d8a4719cf9890c2e66699a40"

