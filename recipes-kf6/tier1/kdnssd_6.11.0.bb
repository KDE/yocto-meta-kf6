# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kdnssd-6.11.0.tar.xz"
SRC_URI[sha256sum] = "69db354bb2a6faac16ec1eb77e6f71308f8ebd9205967c75db5bac937e799bd9"

