# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kquickcharts-6.1.0.tar.xz"
SRC_URI[sha256sum] = "761b5738ff1a1bb1fe68f0427e2888e25c901b6fad4401676386e27a06e3a4c7"

