# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/breeze-icons-5.248.0.tar.xz"
SRC_URI[sha256sum] = "2612f65da0fddbf9e34cda359294284363d504d9d75cff5b30ae9c366f5ee0dd"

