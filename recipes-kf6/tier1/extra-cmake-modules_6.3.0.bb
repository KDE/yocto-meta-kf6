# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/extra-cmake-modules-6.3.0.tar.xz"
SRC_URI[sha256sum] = "1368f8fba95c475a409eff05f78baf49ccd2655889d1e94902bfc886785af818"

