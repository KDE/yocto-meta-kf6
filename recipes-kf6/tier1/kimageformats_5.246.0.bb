# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kimageformats-5.246.0.tar.xz"
SRC_URI[sha256sum] = "0c1ef345d3e8617686e50471e2b3d197d5909a2b18b89ecee12bc36b62289016"

