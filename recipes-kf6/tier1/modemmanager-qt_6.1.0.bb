# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/modemmanager-qt-6.1.0.tar.xz"
SRC_URI[sha256sum] = "853baef5bd810c8a64d4c60f748ef1842b7368e6a952a2f93cd48d85eb5f4970"

