# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kidletime-6.18.0.tar.xz"
SRC_URI[sha256sum] = "44afc88543b23c519eb5f55e7c5120ccd6d4eb2eaaa5bee24e3fb5e4a695dab7"

