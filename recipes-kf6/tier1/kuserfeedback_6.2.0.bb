# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kuserfeedback-6.2.0.tar.xz"
SRC_URI[sha256sum] = "829c52db15d69b90e6d22b08deacdedcd13423c901e4dab63893e814b4e76858"

