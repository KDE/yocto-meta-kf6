# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kcodecs-6.4.0.tar.xz"
SRC_URI[sha256sum] = "2ca3e70634e8116dd32601c551e092cf9941ea1d19ae501eed9e5477e298bfd4"

