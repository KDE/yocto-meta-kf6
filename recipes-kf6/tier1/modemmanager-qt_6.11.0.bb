# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/modemmanager-qt-6.11.0.tar.xz"
SRC_URI[sha256sum] = "a636323902c57a9abf199168e9c33b3432c538e276251e6bb7ce753fffef5fee"

