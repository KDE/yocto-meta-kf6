# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kitemmodels-5.248.0.tar.xz"
SRC_URI[sha256sum] = "884e5b6fb09d2f95aa03ebe3f10f28ece2b79b68859721a20d3b12a87ff17c98"

