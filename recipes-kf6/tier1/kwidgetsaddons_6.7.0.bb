# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kwidgetsaddons-6.7.0.tar.xz"
SRC_URI[sha256sum] = "bd36342893863e6110c5f1245f8ae0b3a338275f4eaf124b15585d2fe492329a"

