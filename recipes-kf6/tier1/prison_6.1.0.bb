# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/prison-6.1.0.tar.xz"
SRC_URI[sha256sum] = "1708710769af1953e7f3cca150d43bdb96208564f894779eb397b67cf5261ef4"

