# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/sonnet-6.8.0.tar.xz"
SRC_URI[sha256sum] = "c421b460214f3a25842abcb2605251b9da89b629ad936160d39d4aa502405636"

