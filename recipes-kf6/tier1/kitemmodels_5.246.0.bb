# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kitemmodels-5.246.0.tar.xz"
SRC_URI[sha256sum] = "7776fec0cf53061d511d8cde30a4235536ab1cb9edcc05074e0e819ec81764bc"

