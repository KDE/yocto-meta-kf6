# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kcalendarcore-6.7.0.tar.xz"
SRC_URI[sha256sum] = "8e5282d8d7a0ce0a1a1bdb32133ba4102d06070105513e712dafe76e32647dfb"

