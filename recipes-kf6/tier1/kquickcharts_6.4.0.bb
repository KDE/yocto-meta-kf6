# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kquickcharts-6.4.0.tar.xz"
SRC_URI[sha256sum] = "a41629caef3877ce03c739c0950f094890f5b2a20a041dd338bdeb240c6401de"

