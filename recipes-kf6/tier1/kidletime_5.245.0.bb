# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kidletime-5.245.0.tar.xz"
SRC_URI[sha256sum] = "525907272e42016d2bbe229b6ab07fdce89866b173e585b26006fc1b6a2cedbf"

