# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kplotting-6.10.0.tar.xz"
SRC_URI[sha256sum] = "6941d93019bfb1e9977cfa592ba110fbf9c3b7f247af40f336e040071f922d3f"

