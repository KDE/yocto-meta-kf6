# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/sonnet-6.10.0.tar.xz"
SRC_URI[sha256sum] = "99c0bca563594fd115f31f18ad3264770046290c6695ded0d2aa3c2eddb0d4b7"

