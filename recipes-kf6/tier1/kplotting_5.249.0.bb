# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kplotting-5.249.0.tar.xz"
SRC_URI[sha256sum] = "e02d725e7b212de708b27757bc7c60204b146e795025bed347223c814046d6b4"

