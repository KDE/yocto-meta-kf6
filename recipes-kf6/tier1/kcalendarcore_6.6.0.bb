# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kcalendarcore-6.6.0.tar.xz"
SRC_URI[sha256sum] = "1ab6390411f8681e0559cc7b3c2f3b4384d607a408681077535ff993606362f8"

