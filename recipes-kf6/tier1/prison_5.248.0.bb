# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/prison-5.248.0.tar.xz"
SRC_URI[sha256sum] = "9865c666a59f864f90b55d9a553943e212f5e90ec7752bacbddc39911a8bd28e"

