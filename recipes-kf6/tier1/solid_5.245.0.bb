# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/solid-5.245.0.tar.xz"
SRC_URI[sha256sum] = "4b3f752cdbbe06610ed9759d551367977952feb93930e6e50531483b522b4baf"

