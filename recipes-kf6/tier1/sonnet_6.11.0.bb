# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/sonnet-6.11.0.tar.xz"
SRC_URI[sha256sum] = "19441de62d9d97f61e48d26e003543e75607b2ba8f6e4feb19f956289af21d60"

