# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/ktexttemplate-6.17.0.tar.xz"
SRC_URI[sha256sum] = "15d75941d15eac3cd1243066b13a30d6c1451ca630b0c29b3624be34ad73e972"

