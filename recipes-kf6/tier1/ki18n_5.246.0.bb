# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/ki18n-5.246.0.tar.xz"
SRC_URI[sha256sum] = "4527ce98b1d159d567e0e6858a3b2b8d559b89267e944f38b486c3975d709d6e"

