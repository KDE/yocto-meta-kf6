# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kcalendarcore-6.0.0.tar.xz"
SRC_URI[sha256sum] = "641356ac286c1a5287327ce8fa2529bf53048e439d1ff672c925d4ab7e0eb7c2"

