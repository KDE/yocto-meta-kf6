# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kuserfeedback-6.0.0.tar.xz"
SRC_URI[sha256sum] = "02f1af108e253c842526d31c997a1777b8f7a6e5b8698b5b1267ce1ec128af2b"

