# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kguiaddons-6.18.0.tar.xz"
SRC_URI[sha256sum] = "2e2b872802d1b27b185512ffa9895906e7aa3438cbf137846ccff8216bbec466"

