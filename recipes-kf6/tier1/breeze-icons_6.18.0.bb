# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/breeze-icons-6.18.0.tar.xz"
SRC_URI[sha256sum] = "4796c4ee6059a777ad8d954a4584e81fdf5047a94a7988fc374052c427bc0b60"

