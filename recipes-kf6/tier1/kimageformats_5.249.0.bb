# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kimageformats-5.249.0.tar.xz"
SRC_URI[sha256sum] = "031a2e170b942d3e679a8f33a8b4a4d949bf980ff9291d876aaeed85018f4786"

