# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kcodecs-6.3.0.tar.xz"
SRC_URI[sha256sum] = "6902531afc3d47d543feb971c2bc04901af265e6730a477af4400073b22ec6ec"

