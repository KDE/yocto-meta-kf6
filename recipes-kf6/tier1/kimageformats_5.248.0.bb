# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kimageformats-5.248.0.tar.xz"
SRC_URI[sha256sum] = "1167c664357978c787ee745c54712efaf02e795789d53c5ce7d8f91c934691b0"

