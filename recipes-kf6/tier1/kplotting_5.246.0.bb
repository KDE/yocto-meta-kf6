# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kplotting-5.246.0.tar.xz"
SRC_URI[sha256sum] = "e46217691e444541332da98d76aee120a5bf5a3fc35e60df232bc96451ea89b3"

