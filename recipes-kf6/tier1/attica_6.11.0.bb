# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/attica-6.11.0.tar.xz"
SRC_URI[sha256sum] = "e7b7c03d7656a5970e02d61c3f8d2760b2c3da46d3f6464bfc254a733b263fb3"

