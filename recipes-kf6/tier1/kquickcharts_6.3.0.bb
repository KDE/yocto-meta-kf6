# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kquickcharts-6.3.0.tar.xz"
SRC_URI[sha256sum] = "250e522adfbf48b3f2763f4ec378a20337a1ca2e5b0e2cd8b3615d7a3fed8fc7"

