# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/networkmanager-qt-6.6.0.tar.xz"
SRC_URI[sha256sum] = "06392d71e6e09758cb1b433d3b1dc667cb59dd7a96b3510f232b5cadff332e40"

