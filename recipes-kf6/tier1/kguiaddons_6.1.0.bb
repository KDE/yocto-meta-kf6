# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kguiaddons-6.1.0.tar.xz"
SRC_URI[sha256sum] = "08d88452ae4bcdc073891499d9b414129cdc5982bd3bad88726dbef28ee5ac53"

