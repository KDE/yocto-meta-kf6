# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kdbusaddons-5.248.0.tar.xz"
SRC_URI[sha256sum] = "395c392ebb5eb01e36b291780dafdd72b6f221dd47209f3b37f56452e99db4fc"

