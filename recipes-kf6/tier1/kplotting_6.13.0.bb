# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kplotting-6.13.0.tar.xz"
SRC_URI[sha256sum] = "918b56f9d0ac677d7c4ebe3f1249dab5c7d46afd8a28f940751655fbc4935916"

