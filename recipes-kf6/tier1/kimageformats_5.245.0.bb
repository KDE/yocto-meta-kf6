# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kimageformats-5.245.0.tar.xz"
SRC_URI[sha256sum] = "82c01c536cd1eecb7928e14d022497b4367daf1451b070cf296077699bf54df4"

