# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/networkmanager-qt-6.2.0.tar.xz"
SRC_URI[sha256sum] = "7be22a6bbc5843b1ada0a170fb56c9c96bef643d7d485413f2af792914ed02d2"

