# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kdbusaddons-6.0.0.tar.xz"
SRC_URI[sha256sum] = "11e70d0c7239bd818962d91cdb94aeba94748055c77003a4f64ff14dab0ae989"

