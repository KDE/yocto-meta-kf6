# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kcoreaddons-6.0.0.tar.xz"
SRC_URI[sha256sum] = "eab838201b45ac98c412f64d234e89d62357f275ae9ae966d073a64c67a526ef"

