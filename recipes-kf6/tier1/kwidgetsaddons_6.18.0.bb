# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kwidgetsaddons-6.18.0.tar.xz"
SRC_URI[sha256sum] = "0c2fb00744ffd9ecb7531ee5a79c1db4b406753f250565122f3add93cf200afb"

