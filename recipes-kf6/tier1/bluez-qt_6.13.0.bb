# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/bluez-qt-6.13.0.tar.xz"
SRC_URI[sha256sum] = "1a99954a0aad70d30e7b60e80b67332534743ec4556ebdb27a6f40b6f1149142"

