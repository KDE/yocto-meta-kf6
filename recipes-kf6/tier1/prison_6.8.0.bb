# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/prison-6.8.0.tar.xz"
SRC_URI[sha256sum] = "bae7b5a76c46e2b8b7c81c1aaaf20721d050cfdf48291d2bcc66f57590b2deb3"

