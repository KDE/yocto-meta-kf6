# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kirigami-6.8.0.tar.xz"
SRC_URI[sha256sum] = "0e0b90ac96ba49630e2c01d8977bd8c51c9ab1808313fc88f60de179700742a2"

