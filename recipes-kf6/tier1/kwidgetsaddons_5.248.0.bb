# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kwidgetsaddons-5.248.0.tar.xz"
SRC_URI[sha256sum] = "1661f0e12d0dce78b792d0576b8800dec15e88d18190c9cb98ccf603da53eff1"

