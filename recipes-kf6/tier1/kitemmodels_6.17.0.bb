# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kitemmodels-6.17.0.tar.xz"
SRC_URI[sha256sum] = "b9004417b5e9bb3309434ab90819889590f6bfa32d4a65388d052df432c0b166"

