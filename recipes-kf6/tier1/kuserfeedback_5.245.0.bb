# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kuserfeedback-5.245.0.tar.xz"
SRC_URI[sha256sum] = "8e671180bd6d372be3bf9d7e2544cb03b1a294cf5a710aadcf382a522ed03710"

