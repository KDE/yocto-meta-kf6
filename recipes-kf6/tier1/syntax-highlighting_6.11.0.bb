# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/syntax-highlighting-6.11.0.tar.xz"
SRC_URI[sha256sum] = "b23dbbe195030a2927caafc5fdf4ca7a372c44ca95013d6115037fe62e1fcb51"

