# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/extra-cmake-modules-6.7.0.tar.xz"
SRC_URI[sha256sum] = "d81de82692d3d2bb77110332a65c8266252becc2c3f307ce814990ce5607b8dc"

