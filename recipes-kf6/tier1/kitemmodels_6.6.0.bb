# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kitemmodels-6.6.0.tar.xz"
SRC_URI[sha256sum] = "fe0677bd6eaf2bccd350e7b80eebac382908fc2388af6716171ad77417ee7802"

