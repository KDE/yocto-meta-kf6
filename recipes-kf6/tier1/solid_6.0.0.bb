# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/solid-6.0.0.tar.xz"
SRC_URI[sha256sum] = "75c5d254eeceb917c35cb0e32beff76a2cf1458f773ecd0e7795b47dad5aadd3"

