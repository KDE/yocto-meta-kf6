# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kplotting-6.18.0.tar.xz"
SRC_URI[sha256sum] = "c9fdb99fd1c75f588e2f15ef84333feadf327a878c24324e44493d03e593ebc9"

