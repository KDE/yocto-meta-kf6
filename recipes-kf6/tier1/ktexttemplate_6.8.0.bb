# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/ktexttemplate-6.8.0.tar.xz"
SRC_URI[sha256sum] = "3a83dafb4075af0bb015556a64205094fcca2bac5b9fb0dee614eaff252a0412"

