# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kuserfeedback-6.7.0.tar.xz"
SRC_URI[sha256sum] = "4def8d0d6ef227807b6066cb762cec352452a18e0e28b56aecce8ef3ceb52761"

