# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kglobalaccel-6.2.0.tar.xz"
SRC_URI[sha256sum] = "c74727fef4a39680e36c5ed27cdb4c5b755043795fa52774ee3bc6a3b568e724"

