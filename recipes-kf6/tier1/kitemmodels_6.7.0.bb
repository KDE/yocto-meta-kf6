# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kitemmodels-6.7.0.tar.xz"
SRC_URI[sha256sum] = "0aa0205323baf2d519ebb8f96ce7ed5524a8164a7440d905f977418bfbe6d349"

