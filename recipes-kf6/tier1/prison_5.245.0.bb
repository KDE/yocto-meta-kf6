# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/prison-5.245.0.tar.xz"
SRC_URI[sha256sum] = "4dc80492074cd44fedbf69fc2c7cf40d2e11f54e1591844b931f5d80321ab793"

