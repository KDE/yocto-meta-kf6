# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kquickcharts-6.8.0.tar.xz"
SRC_URI[sha256sum] = "36e81111a7faed208362746f86646ed104e3e314a182e9287cf2d214f2610239"

