# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kconfig-6.18.0.tar.xz"
SRC_URI[sha256sum] = "517cbf6747df9289d6fce860a73d49e59354685334ae468ecd53f1067d9d618b"

