# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kplotting-6.3.0.tar.xz"
SRC_URI[sha256sum] = "f8e7fa347d0e6bab924f3347716eb5cc468b96b296b52974d392df030dba9521"

