# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/breeze-icons-5.245.0.tar.xz"
SRC_URI[sha256sum] = "25f536613bb49049c9559928a167148a45a4b8d7d8cda03c9b9e31ed30ae038c"

