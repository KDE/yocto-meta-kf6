# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/ki18n-6.4.0.tar.xz"
SRC_URI[sha256sum] = "c069e559e3a311bf977f136d77732c5f3e4253752deff9ba999a6a8d7b4ae255"

