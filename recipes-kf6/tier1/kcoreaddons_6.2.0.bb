# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kcoreaddons-6.2.0.tar.xz"
SRC_URI[sha256sum] = "3f9836a3ce5e72883bf032587b745ce55435aa7627174579d2e018da717338ed"

