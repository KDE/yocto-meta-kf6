# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/syntax-highlighting-6.8.0.tar.xz"
SRC_URI[sha256sum] = "ed3c7d3d92c154d9af39a1aba39166b07e6411c18c3100116208f3a4423b1257"

