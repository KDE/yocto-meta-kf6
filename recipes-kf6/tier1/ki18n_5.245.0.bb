# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/ki18n-5.245.0.tar.xz"
SRC_URI[sha256sum] = "ac94633082bc0f5b5350ec3f6405a4886edd147b2322ce41edb4a1744bf43b20"

