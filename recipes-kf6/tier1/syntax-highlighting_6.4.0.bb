# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/syntax-highlighting-6.4.0.tar.xz"
SRC_URI[sha256sum] = "1f825afa7ca094937f1b8d357ae6b2cd37e58accf009290341ebada288c51505"

