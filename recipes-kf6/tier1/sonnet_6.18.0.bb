# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/sonnet-6.18.0.tar.xz"
SRC_URI[sha256sum] = "2d94c957a3c5f2232653ad782b291e2b959eea6dca83cc09cae621bc9834ab25"

