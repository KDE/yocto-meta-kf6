# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/prison-6.10.0.tar.xz"
SRC_URI[sha256sum] = "b4a0f395eca50c818f8e0656b04664783453b1a9a709a4a45a8ae2e273602c7b"

