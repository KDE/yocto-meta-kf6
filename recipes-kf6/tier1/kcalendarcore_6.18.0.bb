# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kcalendarcore-6.18.0.tar.xz"
SRC_URI[sha256sum] = "4d2330af35d56c59ee69f08f3845babee9896d00012bccfbb143bdc571bc58e7"

