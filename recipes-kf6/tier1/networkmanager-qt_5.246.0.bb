# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/networkmanager-qt-5.246.0.tar.xz"
SRC_URI[sha256sum] = "7067ac9d916c4edbe9f43494c490439df93287f9f6bef360f7f6488d53505391"

