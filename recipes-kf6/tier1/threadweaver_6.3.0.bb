# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/threadweaver-6.3.0.tar.xz"
SRC_URI[sha256sum] = "81201f8f9918d6967b76a5c8c468481289e5bf56351b3e140cce532821f7d913"

