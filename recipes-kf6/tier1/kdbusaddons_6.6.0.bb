# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kdbusaddons-6.6.0.tar.xz"
SRC_URI[sha256sum] = "521315f80d31e2db4e4344ebf2436a22e75475b70edabe8157f4afb4a2cb42ad"

