# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kitemviews-6.7.0.tar.xz"
SRC_URI[sha256sum] = "5e635162993c9f1e15f3a1109ca3227d0d2ce57cf7070615651b65cf790db049"

