# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/karchive-6.1.0.tar.xz"
SRC_URI[sha256sum] = "576c7133cfb994b530bd7377030b926bda227aa2ae420d5d8538f2681926f82c"

