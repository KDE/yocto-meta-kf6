# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kwidgetsaddons-6.2.0.tar.xz"
SRC_URI[sha256sum] = "03cef2f66aec6b7f7b2276c47e720bdab939b05b77b70345e7f076d3dead8211"

