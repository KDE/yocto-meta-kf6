# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kdbusaddons-6.10.0.tar.xz"
SRC_URI[sha256sum] = "e88bfaa6a10f80d9f7b2116281c4485213984caed555ac68557bb53ee88bbb32"

