# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kitemviews-6.3.0.tar.xz"
SRC_URI[sha256sum] = "d8657d155611631834a800a6fb0aac110b6baa4435de00fbd6048bd9f1a2d42f"

