# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kholidays-6.3.0.tar.xz"
SRC_URI[sha256sum] = "9f99e118c73da1d53805cb38ee876115d75ad5eb5fb108a38e6ae880e7cfac5e"

