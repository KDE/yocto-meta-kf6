# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/modemmanager-qt-6.10.0.tar.xz"
SRC_URI[sha256sum] = "640a3f96487f3e875e83ef815f14e1077042ae9ee83276b3d7f7fc3875e2ee15"

