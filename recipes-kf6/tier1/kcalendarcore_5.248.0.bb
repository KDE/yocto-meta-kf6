# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kcalendarcore-5.248.0.tar.xz"
SRC_URI[sha256sum] = "c6b64d34f1ce22e1cc5a2ddb72b0850570180c14becdaafbf4d5557e0ad9f9a2"

