# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/bluez-qt-6.8.0.tar.xz"
SRC_URI[sha256sum] = "371a89f7c5a9c88dfdeeb2dcc6d1ad97b397a23ec10bd6fceae0a835e0740d76"

