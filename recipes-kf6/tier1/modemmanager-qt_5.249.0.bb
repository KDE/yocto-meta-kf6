# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/modemmanager-qt-5.249.0.tar.xz"
SRC_URI[sha256sum] = "75aa829f094db4b13e8d3855911cf8a6f098a390ee0f0fa0e20a1297a20c4ebf"

