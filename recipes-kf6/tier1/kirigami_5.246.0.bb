# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kirigami-5.246.0.tar.xz"
SRC_URI[sha256sum] = "df3f21ed1a3c8d25a2e7ca50d90076003da17e200534a70859797bee3c76020e"

