# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kitemviews-5.246.0.tar.xz"
SRC_URI[sha256sum] = "00fb7a695c8a09bb428cc718638bc1a7ed23bf85352443a30d5067a9a8efb4ff"

