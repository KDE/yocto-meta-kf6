# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/threadweaver-6.10.0.tar.xz"
SRC_URI[sha256sum] = "136a636a33ccfa9a375a2e1ee503760a0a910002b972be0eef20352eb106bb84"

