# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kcodecs-6.0.0.tar.xz"
SRC_URI[sha256sum] = "ceba44dcdc251d443bbd6cb77d1219d876af8cc2ae4710472aace78122395abe"

