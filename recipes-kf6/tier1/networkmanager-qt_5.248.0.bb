# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/networkmanager-qt-5.248.0.tar.xz"
SRC_URI[sha256sum] = "f8f7a634695f4f754701278e113aeaa0e4cc638b6dd9c6788f5fd4d66eab7a3c"

