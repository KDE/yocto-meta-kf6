# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/syntax-highlighting-6.6.0.tar.xz"
SRC_URI[sha256sum] = "bf946d2606ef293949a51a7446f150954e2f78193ff5461b4abd198939b9f1b6"

