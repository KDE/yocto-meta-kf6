# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kwidgetsaddons-5.245.0.tar.xz"
SRC_URI[sha256sum] = "0cf71ba3ca7c16b2c81e7965d556d10660a7cdc4925d79034295279a8ee5a6e5"

