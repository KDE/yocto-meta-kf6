# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/prison-6.2.0.tar.xz"
SRC_URI[sha256sum] = "87719675c1652f0773149b8de384f406949a6d65abe25a6d3611e110d12d6ca8"

