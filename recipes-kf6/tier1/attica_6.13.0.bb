# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/attica-6.13.0.tar.xz"
SRC_URI[sha256sum] = "acccb7ff62e1e421faa5ffd381b41777d0c7bfba268fae1ed802b51a6bd98a87"

