# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kitemviews-5.245.0.tar.xz"
SRC_URI[sha256sum] = "0a7b9895112777e22cbb4d1480b3267c86b2fa55a159cfc5e68f4f9768fb4a9d"

