# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/sonnet-6.13.0.tar.xz"
SRC_URI[sha256sum] = "d47465a9d623257cfb0192c3a4dc24733490aa8952310422e402d828ad461eee"

