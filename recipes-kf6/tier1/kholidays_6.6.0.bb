# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kholidays-6.6.0.tar.xz"
SRC_URI[sha256sum] = "712b2be318997022be28374195a49e8c7ca2a130295aab6ace7b88d7ec0f2b0f"

