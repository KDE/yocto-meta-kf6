# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/karchive-6.8.0.tar.xz"
SRC_URI[sha256sum] = "e903eb54b875258727fd524b2489d2a5019973e27df67b33bb56fba91e4eec34"

