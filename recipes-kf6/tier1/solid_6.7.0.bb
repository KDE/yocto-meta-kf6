# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/solid-6.7.0.tar.xz"
SRC_URI[sha256sum] = "3673f17776c30d9523fe40b8f38e62be1037610050f782c136da1ac04b20e6e7"

