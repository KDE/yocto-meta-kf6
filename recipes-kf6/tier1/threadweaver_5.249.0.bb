# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/threadweaver-5.249.0.tar.xz"
SRC_URI[sha256sum] = "3f7c5ecdbc15fb5658c78bff8da857841e15530e19da6757f98361883c90f168"

