# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kitemmodels-6.10.0.tar.xz"
SRC_URI[sha256sum] = "83859a4aee67bf5e768a93325422264cb9e847013f281c5cb02e631c3b3b0007"

