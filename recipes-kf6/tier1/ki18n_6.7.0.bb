# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/ki18n-6.7.0.tar.xz"
SRC_URI[sha256sum] = "555b5bc19546c3a791c69724e238c5d1710a9575cf8740012f8fc546f354122b"

