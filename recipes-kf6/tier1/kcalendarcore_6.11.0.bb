# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kcalendarcore-6.11.0.tar.xz"
SRC_URI[sha256sum] = "ea261324d1b80ef4786b86cf86bfa32c332aa0357b05ba299b13f54be69a7380"

