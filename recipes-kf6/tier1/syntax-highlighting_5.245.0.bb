# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/syntax-highlighting-5.245.0.tar.xz"
SRC_URI[sha256sum] = "3685e19697cdbfc897971ebf588aa7ef1368553484e71b781b370ed242353111"

