# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kquickcharts-6.10.0.tar.xz"
SRC_URI[sha256sum] = "a2036f7b1ee7abb9c278c7822fc18723d661d856da9dbf9f006ceebed731598f"

