# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/karchive-6.17.0.tar.xz"
SRC_URI[sha256sum] = "60647c24646a43f67deaf37e20246df9d379fa3f7513fe8536a1dfa330865b40"

