# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/syntax-highlighting-6.13.0.tar.xz"
SRC_URI[sha256sum] = "d6f19bb886d6e1c7251d813497f14ecc9dac413253764eb61a8f3a836806450d"

