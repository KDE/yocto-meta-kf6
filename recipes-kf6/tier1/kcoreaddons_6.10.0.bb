# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kcoreaddons-6.10.0.tar.xz"
SRC_URI[sha256sum] = "89bf28747915e987cab21c77397b0971caffa1258b6f575543d73d4188184a72"

