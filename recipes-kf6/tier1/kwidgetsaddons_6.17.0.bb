# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kwidgetsaddons-6.17.0.tar.xz"
SRC_URI[sha256sum] = "dcb33387953cd0429d4297d628b4872e7a3a970cce5ea84b446677d8b7487ea1"

