# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kcoreaddons-6.8.0.tar.xz"
SRC_URI[sha256sum] = "28977f478be5d7d5f5650876bf7b806674ed6fc609d703eea329a819fa4ad99c"

