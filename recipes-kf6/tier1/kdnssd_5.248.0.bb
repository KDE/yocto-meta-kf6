# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kdnssd-5.248.0.tar.xz"
SRC_URI[sha256sum] = "4e85e2d0e972d553918f25063cb83740b809be721e0e0ddda7dd48c109241788"

