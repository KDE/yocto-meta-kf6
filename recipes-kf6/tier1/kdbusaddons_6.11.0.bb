# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kdbusaddons-6.11.0.tar.xz"
SRC_URI[sha256sum] = "62e0f3b0487ef1ab729fc85bcb5498c9449e0b74fe8049779434158bb8b12a87"

