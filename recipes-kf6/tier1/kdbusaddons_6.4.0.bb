# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kdbusaddons-6.4.0.tar.xz"
SRC_URI[sha256sum] = "212fa6be4194a819f0fb48f3c6fd2b58846ba911612b73e97dc7e90f6104c987"

