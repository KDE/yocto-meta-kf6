# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kguiaddons-6.3.0.tar.xz"
SRC_URI[sha256sum] = "e1519b1fc01ec3731c2926b69aee7a32c13e0f92178834fef484ac37d5dc3201"

