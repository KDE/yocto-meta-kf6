# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/solid-6.6.0.tar.xz"
SRC_URI[sha256sum] = "88f67f369c720aaa0d347ee09273684335505c4f8faf5f7684d1acb7229455f1"

