# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kcodecs-6.18.0.tar.xz"
SRC_URI[sha256sum] = "247eda9ade502699062c7baaca7bb93691a308f202c165954652875ebe777426"

