# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/networkmanager-qt-5.249.0.tar.xz"
SRC_URI[sha256sum] = "594b21f45c4a8a8055fe92926ac8f24701d49e697c54142496cff41ee60f9147"

