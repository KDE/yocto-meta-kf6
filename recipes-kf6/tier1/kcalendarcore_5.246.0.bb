# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kcalendarcore-5.246.0.tar.xz"
SRC_URI[sha256sum] = "e45a3e4a617dfa97bce648f6eebc527a67246f9596a86ce96d382d360839df94"

