# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kwindowsystem-6.6.0.tar.xz"
SRC_URI[sha256sum] = "2c771ebf1a297774305dfcf79423db0684da0662eacb99e5740b00f3ffe332e5"

