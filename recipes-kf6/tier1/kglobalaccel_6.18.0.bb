# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kglobalaccel-6.18.0.tar.xz"
SRC_URI[sha256sum] = "cb9a7b0ee933656207958fb295bf14fbfbc828d5d968f601fd28ad6877fdb438"

