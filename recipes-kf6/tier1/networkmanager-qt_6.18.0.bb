# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/networkmanager-qt-6.18.0.tar.xz"
SRC_URI[sha256sum] = "492836a74a03ba43facf52e827428f888f13d6e2bb8374819869707280a0310c"

