# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kcalendarcore-5.249.0.tar.xz"
SRC_URI[sha256sum] = "09d4c3f360fe8e2c331af87ebba9f84d9b8eaac64e3bd49902b6dd3fe447739d"

