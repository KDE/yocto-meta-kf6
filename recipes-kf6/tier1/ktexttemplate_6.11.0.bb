# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/ktexttemplate-6.11.0.tar.xz"
SRC_URI[sha256sum] = "b0f30c6e49a132cdf587228e0ba1e1d974cc155d233b57ff617f5d55e7f7b905"

