# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/attica-6.18.0.tar.xz"
SRC_URI[sha256sum] = "eb2b2be33cc83512c77af2559fcaf7fc58ad191abb82cf40b17b2e9e8400e336"

