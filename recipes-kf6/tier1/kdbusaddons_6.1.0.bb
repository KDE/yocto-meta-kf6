# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kdbusaddons-6.1.0.tar.xz"
SRC_URI[sha256sum] = "b423a4ca1fcab973b9454386efbaf5dc2c642d21ee9125d73b8fc67f80463541"

