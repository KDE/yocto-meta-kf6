# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kholidays-6.8.0.tar.xz"
SRC_URI[sha256sum] = "162b8ade42de80415380f6476a285fbfab5bb270f35b0d7d13baa1c34a5fb164"

