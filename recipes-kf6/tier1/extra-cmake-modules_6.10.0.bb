# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/extra-cmake-modules-6.10.0.tar.xz"
SRC_URI[sha256sum] = "506989a0d400913403e669c1912238db053cd6b38dff74b17e2e6f879c79cca0"

