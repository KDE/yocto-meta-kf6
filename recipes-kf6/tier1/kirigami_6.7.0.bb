# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kirigami-6.7.0.tar.xz"
SRC_URI[sha256sum] = "4d645a0374d33b9465e79e3e17170882e2cbda1526f45bc5b6b176dadda77d76"

