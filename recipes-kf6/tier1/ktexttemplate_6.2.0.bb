# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/ktexttemplate-6.2.0.tar.xz"
SRC_URI[sha256sum] = "a59b0e6e3acb94737b82eafac47d14725255c6c6f21c2371ccf9ecc1062cf2ca"

