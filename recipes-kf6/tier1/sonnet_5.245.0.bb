# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/sonnet-5.245.0.tar.xz"
SRC_URI[sha256sum] = "4fcf419eed4619fb3c6969e341adf0de24d0633e64631e6dfc3cd9b45871086a"

