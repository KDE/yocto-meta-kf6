# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kquickcharts-6.13.0.tar.xz"
SRC_URI[sha256sum] = "bce07e95a460f44cb1a5191a96fdb22dafee681f09dbed28fe7508e33219ea0b"

