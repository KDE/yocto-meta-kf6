# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/bluez-qt-5.248.0.tar.xz"
SRC_URI[sha256sum] = "9e58e11cedfbd5095981ad05fa11afa1ca7a29fb24d5a993d3661ca13531ea89"

