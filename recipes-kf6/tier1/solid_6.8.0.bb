# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/solid-6.8.0.tar.xz"
SRC_URI[sha256sum] = "ace5145f59db548bcf423cb6b70fd870fefba37f07a649164394a802b3ca7941"

