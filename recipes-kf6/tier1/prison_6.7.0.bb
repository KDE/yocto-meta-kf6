# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/prison-6.7.0.tar.xz"
SRC_URI[sha256sum] = "0a053a80beae232cef5da3f6525b14ee649b275cea64de0c0ffad41c3f2ec260"

