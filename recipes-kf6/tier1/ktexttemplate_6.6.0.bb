# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/ktexttemplate-6.6.0.tar.xz"
SRC_URI[sha256sum] = "23611a7724d9ccb534cba22dc88885748cf2ec9037d3dccad5cc54a3d4bdb954"

