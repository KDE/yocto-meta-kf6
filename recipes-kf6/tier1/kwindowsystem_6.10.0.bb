# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kwindowsystem-6.10.0.tar.xz"
SRC_URI[sha256sum] = "046b7aa2247811323e48b629884b824a6ffec475df2316256e7ff0b9df677944"

