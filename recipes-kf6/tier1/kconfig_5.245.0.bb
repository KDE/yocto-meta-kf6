# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kconfig-5.245.0.tar.xz"
SRC_URI[sha256sum] = "e6ed946703bc88dc80c61410d20b731e407c6914e62fecb54bdeebaf8ca1148e"

