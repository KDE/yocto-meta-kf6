# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kirigami-6.11.0.tar.xz"
SRC_URI[sha256sum] = "22392c95bb835f11626250f0728ce73590db638814e7181148fcf66a1f442ea6"

