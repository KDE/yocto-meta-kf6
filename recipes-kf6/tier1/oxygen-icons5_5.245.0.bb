# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/oxygen-icons5-5.245.0.tar.xz"
SRC_URI[sha256sum] = "<!DOCTYPE
<html><head>
<title>404
</head><body>
<h1>Not
<p>The
<hr>
<address>Apache/2.4.52
</body></html>"

