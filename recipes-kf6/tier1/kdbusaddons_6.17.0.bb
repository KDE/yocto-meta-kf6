# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kdbusaddons-6.17.0.tar.xz"
SRC_URI[sha256sum] = "57d640bfa11c1660b5dcd3c1c71d605a40542d1657e04d9bf867b761bfe772f4"

