# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/solid-6.10.0.tar.xz"
SRC_URI[sha256sum] = "24892e81a3047f753519dbd384b47635c5a2543d8ee0bf3c299b0fcfef318e8c"

