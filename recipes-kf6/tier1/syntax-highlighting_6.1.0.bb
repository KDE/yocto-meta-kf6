# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/syntax-highlighting-6.1.0.tar.xz"
SRC_URI[sha256sum] = "1e7449052b0e3e97d615d6157e5647958e9bb98fa5d8f9c5d694829c5d67cab6"

