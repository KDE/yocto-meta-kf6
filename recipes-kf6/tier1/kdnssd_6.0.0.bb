# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kdnssd-6.0.0.tar.xz"
SRC_URI[sha256sum] = "0694964ba4adb7e20bd0d1007694440a298b433f6da8647a24bc151dc348b679"

