# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kcalendarcore-6.4.0.tar.xz"
SRC_URI[sha256sum] = "60359b1ed3316113ff0398c3fffc844939807597f7d1ab3317b634b985bdaa57"

