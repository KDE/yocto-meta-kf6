# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kwindowsystem-6.13.0.tar.xz"
SRC_URI[sha256sum] = "4fa83424f39a97d7fe784533d2ad4d4969ff878d26438dda9dc00e30745959ac"

