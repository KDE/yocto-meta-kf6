# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/karchive-5.246.0.tar.xz"
SRC_URI[sha256sum] = "056f37fe61fd04676234f512937110f8403326f61c5d3ee10e1d5cc594d8b41e"

