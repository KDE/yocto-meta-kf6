# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/sonnet-5.249.0.tar.xz"
SRC_URI[sha256sum] = "afc3a7184075d09ab988a8dc6c1279172ae1fa8849314bcf4e9e686b99752b90"

