# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kitemmodels-6.8.0.tar.xz"
SRC_URI[sha256sum] = "4c7ada1b29621803b164c31de3658d5bda1d5d4cf101e973628b9c2fe1982365"

