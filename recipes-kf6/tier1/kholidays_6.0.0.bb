# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kholidays-6.0.0.tar.xz"
SRC_URI[sha256sum] = "482f6375fe536a63b67bad45a0ad3880c74d74fc92a3a935ecb78b29830d9b7f"

