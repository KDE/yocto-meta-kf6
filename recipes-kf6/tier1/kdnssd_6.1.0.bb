# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kdnssd-6.1.0.tar.xz"
SRC_URI[sha256sum] = "3b981f7a69f265ed331346f56d4030d31bbdf1d936f62c276c7e333b3b67b712"

