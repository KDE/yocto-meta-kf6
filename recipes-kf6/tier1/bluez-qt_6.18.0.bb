# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/bluez-qt-6.18.0.tar.xz"
SRC_URI[sha256sum] = "9340849075a7aa3fe9f21e2d2b838962c0ae84edfa16a4b4cf17f4022305ceb3"

