# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kwidgetsaddons-6.13.0.tar.xz"
SRC_URI[sha256sum] = "a1538829997319f8af0044ed7ae84f79b4e18cf2b32cacd4fdc4748b8f1c7406"

