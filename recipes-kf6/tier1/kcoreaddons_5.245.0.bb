# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kcoreaddons-5.245.0.tar.xz"
SRC_URI[sha256sum] = "13de65853530e20d95a9053386f1ac0c270713c63c5e4277887cf2b513ec9ab2"

