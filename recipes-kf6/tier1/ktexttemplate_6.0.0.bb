# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/ktexttemplate-6.0.0.tar.xz"
SRC_URI[sha256sum] = "b964e612d2d623bbcf3f5a76ae4ba4408f80de6c588074c67f18834b5e48274c"

