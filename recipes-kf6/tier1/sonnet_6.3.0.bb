# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/sonnet-6.3.0.tar.xz"
SRC_URI[sha256sum] = "6b44dd00ceaa77c3dc9f05f82ca23791cecd887820889cdf8ffc24b384974c7e"

