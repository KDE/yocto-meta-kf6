# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/bluez-qt-6.0.0.tar.xz"
SRC_URI[sha256sum] = "36798f1e7a0a472607435beb2833f6cc77d65cb006decac1ec0b0a3a6f5142eb"

