# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kitemviews-6.11.0.tar.xz"
SRC_URI[sha256sum] = "e3625368e3f8cf6127218cc3e847fbf0176a5978c86228b11a320ad96fea2cbc"

