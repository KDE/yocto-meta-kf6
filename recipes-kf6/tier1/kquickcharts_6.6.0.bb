# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kquickcharts-6.6.0.tar.xz"
SRC_URI[sha256sum] = "d8441008d625763bf7b20a8b1685d09cd69416c6ce4603743e93c16fc5397a47"

