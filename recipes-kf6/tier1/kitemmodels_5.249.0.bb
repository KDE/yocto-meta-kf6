# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kitemmodels-5.249.0.tar.xz"
SRC_URI[sha256sum] = "22a8bd32281182be1399944903e96a3ccc9950c1f8ad21c4f4a52e71ab02b9c8"

