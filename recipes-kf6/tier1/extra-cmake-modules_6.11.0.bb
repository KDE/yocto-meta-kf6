# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/extra-cmake-modules-6.11.0.tar.xz"
SRC_URI[sha256sum] = "69fdab5f0fedfb73d1accff5012d510b486e1dd75c711e925a6912a3e71814b0"

