# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kidletime-6.4.0.tar.xz"
SRC_URI[sha256sum] = "4e2e0455a803ded2bee74d573701d2d95359eaed2f7964f230a40e3058a84c2c"

