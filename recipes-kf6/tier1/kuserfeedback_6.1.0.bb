# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kuserfeedback-6.1.0.tar.xz"
SRC_URI[sha256sum] = "cdfa46fd02773f25820d5a8017d6ca9746d1054cf44e3ae33fff691eb266bc5f"

