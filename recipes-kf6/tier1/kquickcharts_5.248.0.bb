# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kquickcharts-5.248.0.tar.xz"
SRC_URI[sha256sum] = "be6dd4e02c2bda36bc01bcbc18ee90f9a6fa8c607ca60dd85eebfd8f0a4c0b7a"

