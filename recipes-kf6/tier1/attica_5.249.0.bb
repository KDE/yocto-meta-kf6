# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/attica-5.249.0.tar.xz"
SRC_URI[sha256sum] = "efa6aa6355afbbd2b92e3528508f28317117d7d3d9be59c19f23342233ae5673"

