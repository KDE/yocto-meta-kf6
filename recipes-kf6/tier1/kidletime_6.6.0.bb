# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kidletime-6.6.0.tar.xz"
SRC_URI[sha256sum] = "82480a6f06039c2b7e04a75c69f1151b1784edc7bcd27097ac6264b1aa15f427"

