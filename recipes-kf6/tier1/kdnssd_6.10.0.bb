# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kdnssd-6.10.0.tar.xz"
SRC_URI[sha256sum] = "fd8f08501fc40b9a29fc370f7f7871083f2489922e1bd50bc5b0fd78017daa27"

