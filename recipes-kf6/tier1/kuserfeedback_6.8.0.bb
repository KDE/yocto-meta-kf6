# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kuserfeedback-6.8.0.tar.xz"
SRC_URI[sha256sum] = "7e9dc571e35e2634fd43d42a4686c921097828fba5543d4a7a01ef7f9b9dadb5"

