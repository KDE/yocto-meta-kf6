# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kglobalaccel-6.8.0.tar.xz"
SRC_URI[sha256sum] = "caa6d85b08867cb837f08a789798844724d5392320193782a83e14135f669783"

