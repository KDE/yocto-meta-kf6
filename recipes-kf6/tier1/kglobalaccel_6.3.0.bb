# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kglobalaccel-6.3.0.tar.xz"
SRC_URI[sha256sum] = "c08206ca39db1227a2a8a3c8c06922d5908830cb6d52ef212cb597b8c7029df1"

