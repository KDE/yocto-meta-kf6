# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kconfig-5.248.0.tar.xz"
SRC_URI[sha256sum] = "d95f7a8e58ec6573ea38358d637cf194c46451df7810a16c04ebdd950df1ecda"

