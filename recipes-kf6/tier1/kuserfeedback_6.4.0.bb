# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kuserfeedback-6.4.0.tar.xz"
SRC_URI[sha256sum] = "4cc42c4433c80441aec21883899816e812518e8f2c8c10c8d8add9e774538257"

