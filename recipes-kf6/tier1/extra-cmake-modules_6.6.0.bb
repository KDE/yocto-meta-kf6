# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/extra-cmake-modules-6.6.0.tar.xz"
SRC_URI[sha256sum] = "206e23e05ba8934ac7a275c8fdd3704165f558878d3dbe3299f991473997ccb8"

