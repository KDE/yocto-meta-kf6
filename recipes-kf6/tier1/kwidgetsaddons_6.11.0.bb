# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kwidgetsaddons-6.11.0.tar.xz"
SRC_URI[sha256sum] = "1c64e7354804845db0cd83ae671dfb5d2cb08308551a0b6c7b8a339aa6dcb436"

