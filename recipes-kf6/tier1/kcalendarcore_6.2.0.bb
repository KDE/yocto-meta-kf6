# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kcalendarcore-6.2.0.tar.xz"
SRC_URI[sha256sum] = "a3e277c0136a59de635a659f7119d736852c2fff500b2f5fd439f69066f3f209"

