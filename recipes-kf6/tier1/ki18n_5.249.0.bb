# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/ki18n-5.249.0.tar.xz"
SRC_URI[sha256sum] = "f6e507c0f64ad5508c134f77184e102c3588f4d901acba5bc389b0e936f835ba"

