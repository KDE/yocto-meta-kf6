# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/prison-6.17.0.tar.xz"
SRC_URI[sha256sum] = "5542dd0733e06beae6f8cf8bf27ff981f34205fe98125d910be2c53fff47007c"

