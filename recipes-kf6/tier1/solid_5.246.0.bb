# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/solid-5.246.0.tar.xz"
SRC_URI[sha256sum] = "d4dd36d8e777ed142d78638e6f62ad28f681bd3898dd10a0fa41b50d67e9170b"

