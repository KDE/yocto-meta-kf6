# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kplotting-6.2.0.tar.xz"
SRC_URI[sha256sum] = "cddc7e95e3376be1621a347f6e9ffa88ad787b485aa26c7e026336c05277c16d"

