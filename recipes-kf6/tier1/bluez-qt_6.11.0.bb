# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/bluez-qt-6.11.0.tar.xz"
SRC_URI[sha256sum] = "93810ba70a7cac043b227b23ac6a907c52fa2f8aa90ceb4acfe8d6d46b7eae8b"

