# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kquickcharts-5.245.0.tar.xz"
SRC_URI[sha256sum] = "b4c77c41c5319c104759fbab4daf0a85f63a9aef7dc548b885d9c74ec3da270d"

