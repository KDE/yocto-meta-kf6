# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/extra-cmake-modules-5.249.0.tar.xz"
SRC_URI[sha256sum] = "800fbb24496980604886b6f9dbf9c9f44693c73cc924abbe4bab21274ff4379b"

