# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kquickcharts-5.249.0.tar.xz"
SRC_URI[sha256sum] = "aa479b8b67a7394ed8ffb9310b5514fe75fa7353f388d2b615857d1fcdac06cc"

