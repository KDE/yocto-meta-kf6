# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/solid-5.248.0.tar.xz"
SRC_URI[sha256sum] = "045b264a34a710caaaf2f2e60de6250116625b9d5e30c856a18d686329b2c523"

