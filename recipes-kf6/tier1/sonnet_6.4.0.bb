# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/sonnet-6.4.0.tar.xz"
SRC_URI[sha256sum] = "954205989da5d3443bfc256f8b31e05e23effb836f1810894d6fb9cc9d0cdda9"

