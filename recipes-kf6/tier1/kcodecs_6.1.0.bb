# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kcodecs-6.1.0.tar.xz"
SRC_URI[sha256sum] = "f1f0075955b2dd613b5c5f7999844ea1f9e0a09ff3f2cb230653ae9cbd843816"

