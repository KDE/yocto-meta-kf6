# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kquickcharts-6.2.0.tar.xz"
SRC_URI[sha256sum] = "fdd96bf4218a309be28523ac318bd7816e8bd1febf0e771b13359cd658c6756b"

