# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kcodecs-6.2.0.tar.xz"
SRC_URI[sha256sum] = "d040fb03510ca90942e54323b1afd26ec00d459b1b2c54e6eeeece5166842f2f"

