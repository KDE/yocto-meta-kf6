# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kwidgetsaddons-6.1.0.tar.xz"
SRC_URI[sha256sum] = "81225d7ec2d6ea738ded55fe41978deb639c3f77a2daad0eb2e5423aa046e4ce"

