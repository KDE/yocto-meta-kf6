# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/threadweaver-5.245.0.tar.xz"
SRC_URI[sha256sum] = "7a9f112a3c6793520d5d7465baaaafaf99648499f1dc1fe58870ab8f8eee4d6e"

