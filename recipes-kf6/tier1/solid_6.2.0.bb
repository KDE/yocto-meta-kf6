# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/solid-6.2.0.tar.xz"
SRC_URI[sha256sum] = "002a0d2b27599bebc721516681d327876962fdcaf9940f033634fb93a4f9d722"

