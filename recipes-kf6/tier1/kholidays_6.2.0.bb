# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kholidays-6.2.0.tar.xz"
SRC_URI[sha256sum] = "9d7a805287e04281dd59b8ccb1302406a92fe0941e273cac1c724ef6125fac29"

