# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kitemviews-6.10.0.tar.xz"
SRC_URI[sha256sum] = "8b15ff5719ea65e9d0c722eea6412e312d05d9da49c872caf9d97d329d56d76d"

