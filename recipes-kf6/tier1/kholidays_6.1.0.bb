# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kholidays-6.1.0.tar.xz"
SRC_URI[sha256sum] = "83661559ab5770cd561902eeb81be5171922435b539d97f4bc17277da4b9730a"

