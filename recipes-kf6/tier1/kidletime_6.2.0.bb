# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kidletime-6.2.0.tar.xz"
SRC_URI[sha256sum] = "069182e4abfb83f93661d5bb0eaeb14b44e3705fa3492dbdb8ec03bfe6e3d9dc"

