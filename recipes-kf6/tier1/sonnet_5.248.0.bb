# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/sonnet-5.248.0.tar.xz"
SRC_URI[sha256sum] = "d494e3070d7c5a76f0dc92ef49d2207e774b131f4a080836ef270ec6b374e841"

