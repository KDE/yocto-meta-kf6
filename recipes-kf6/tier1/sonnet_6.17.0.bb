# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/sonnet-6.17.0.tar.xz"
SRC_URI[sha256sum] = "4afef6e9ca72edb6c22800b4acfb450df7121e5077c85213aca5f56ab9f4160b"

