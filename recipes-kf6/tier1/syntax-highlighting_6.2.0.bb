# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/syntax-highlighting-6.2.0.tar.xz"
SRC_URI[sha256sum] = "327ed58d20d52502bbfd9278fa1c9e7ab4a846159e5cf630d09fbea144ebbb7f"

