# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kplotting-6.17.0.tar.xz"
SRC_URI[sha256sum] = "6654965b63d0857c31c21817e56931684c32dddf035e83169ca6ea7d6b9a2643"

