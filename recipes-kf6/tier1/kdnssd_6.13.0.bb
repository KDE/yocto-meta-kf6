# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kdnssd-6.13.0.tar.xz"
SRC_URI[sha256sum] = "e3d25dfaa3886dff4851e5b88f652f6bc6e8e8718708bd80ba49875141907e82"

