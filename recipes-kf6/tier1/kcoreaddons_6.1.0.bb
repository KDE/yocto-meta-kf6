# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kcoreaddons-6.1.0.tar.xz"
SRC_URI[sha256sum] = "7608ef9a2483b28a3af82a3024054cdb3c58cf1fdfbd791a02f70efc80ea3343"

