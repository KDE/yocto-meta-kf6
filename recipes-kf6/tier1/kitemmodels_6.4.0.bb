# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kitemmodels-6.4.0.tar.xz"
SRC_URI[sha256sum] = "9608312c5564279b624c4965fbe198bfb2d26804a915cf51a468e31bb9982d61"

