# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kconfig-6.11.0.tar.xz"
SRC_URI[sha256sum] = "c71072aaf2771295b591fc62d4fb657cefb38df29f240ef9c7120854b42d0f7f"

