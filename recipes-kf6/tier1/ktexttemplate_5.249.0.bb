# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/ktexttemplate-5.249.0.tar.xz"
SRC_URI[sha256sum] = "cfa66fe841d1ee75b44612dfa0f4800acfae9a6c3cc76d695e5452135d979b74"

