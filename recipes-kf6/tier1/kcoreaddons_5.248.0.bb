# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kcoreaddons-5.248.0.tar.xz"
SRC_URI[sha256sum] = "ff15b80dbdda016dd7474707e9f275b7b240e0ddef8b502073f6053c5198fa3c"

