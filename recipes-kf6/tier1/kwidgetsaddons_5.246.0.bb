# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kwidgetsaddons-5.246.0.tar.xz"
SRC_URI[sha256sum] = "b1e7dc0eff9bd307b8bccea0a6ad65e74a11139d4b0da4f717bd6ffd84c376f2"

