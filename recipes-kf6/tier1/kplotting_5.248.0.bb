# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kplotting-5.248.0.tar.xz"
SRC_URI[sha256sum] = "7d7f1168b0034b5b77ea202697e9eff50bcd920faf7c06ee473f2fb34206bc25"

