# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kdbusaddons-5.245.0.tar.xz"
SRC_URI[sha256sum] = "fddeddee6e068bbdf3fec37a3e9e541108b46ef82d1ae6b9242a19c3ba9d3683"

