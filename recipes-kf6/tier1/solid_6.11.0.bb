# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/solid-6.11.0.tar.xz"
SRC_URI[sha256sum] = "cdecc7665b801a508b9ad0929b025ac93fe287be503589c8d8c38a520c2508d7"

