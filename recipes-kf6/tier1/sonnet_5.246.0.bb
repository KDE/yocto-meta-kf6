# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/sonnet-5.246.0.tar.xz"
SRC_URI[sha256sum] = "b4125cd67bbdb1587fe3cd7b28385c1d4c71ae893b8caab819abdaa5238de3c8"

