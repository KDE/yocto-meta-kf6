# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kplotting-6.7.0.tar.xz"
SRC_URI[sha256sum] = "130eedc234f0fedaf2c415de895c979454f64c3b049043327d43cd509e2386b3"

