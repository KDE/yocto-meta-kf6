# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kdnssd-6.3.0.tar.xz"
SRC_URI[sha256sum] = "671d48d2de1a974b570eb4f5f6f6a03875fa171eade74b81396a4bb474b9712a"

