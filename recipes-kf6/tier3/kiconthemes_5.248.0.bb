# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kiconthemes-5.248.0.tar.xz"
SRC_URI[sha256sum] = "f044756ff2733d16a5d6d73c29550e4ec8178e5e8e9bb50da820aaa62d8c89b7"

