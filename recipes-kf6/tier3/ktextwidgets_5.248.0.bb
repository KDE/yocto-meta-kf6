# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/ktextwidgets-5.248.0.tar.xz"
SRC_URI[sha256sum] = "b488aeb01b76d27a2f678ba3f16074344637dc8932cd584a25402bade0b5ae63"

