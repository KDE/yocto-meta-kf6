# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/purpose-5.249.0.tar.xz"
SRC_URI[sha256sum] = "39cbc645724a4aa5e6b5a4ebe0a89a5c1e93c3f050449bdfe1a8ce946f044dcb"

