# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kxmlgui-6.1.0.tar.xz"
SRC_URI[sha256sum] = "825ba02aadcabc1ce13a5583295c8b1036c2f14bd1fa46b26431edc44cc6cf0d"

