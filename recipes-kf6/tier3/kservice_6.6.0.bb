# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kservice-6.6.0.tar.xz"
SRC_URI[sha256sum] = "ba0d6323efecaf055655bb6d9dd072e7f889d23969ca4fc55565bda8999101f4"

