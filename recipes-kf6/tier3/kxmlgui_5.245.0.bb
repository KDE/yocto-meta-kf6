# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kxmlgui-5.245.0.tar.xz"
SRC_URI[sha256sum] = "648879f1236c52cadbe82cd4ebffb8f93a36e43e02e32b8ffa64ae2ef6b541df"

