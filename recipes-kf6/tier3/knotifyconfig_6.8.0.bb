# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/knotifyconfig-6.8.0.tar.xz"
SRC_URI[sha256sum] = "c9a31d6f4566b01cddd760de84f5d2962871cd0387993817042fc291699388bf"

