# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/krunner-6.17.0.tar.xz"
SRC_URI[sha256sum] = "9d4a5c0c74b0cfa9e35c31de762633ddec0439c50fa44bc85bec28ada0106912"

