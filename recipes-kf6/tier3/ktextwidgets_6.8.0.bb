# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/ktextwidgets-6.8.0.tar.xz"
SRC_URI[sha256sum] = "5d1d2e32133cbf77eb60d244dcf4fd10c28555e38da5376c023b462b9b68b2b8"

