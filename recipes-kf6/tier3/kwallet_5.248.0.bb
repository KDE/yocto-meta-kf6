# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kwallet-5.248.0.tar.xz"
SRC_URI[sha256sum] = "e8f94e7e32c7e7edcf48d4b4b7d2ed50406f601a00e5ad3b9176f821ac490ee2"

