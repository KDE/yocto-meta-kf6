# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/purpose-5.246.0.tar.xz"
SRC_URI[sha256sum] = "794455525f3a76b978af4201e0437f2ff8e081cbc17bb97a3b9bb6f994aba698"

