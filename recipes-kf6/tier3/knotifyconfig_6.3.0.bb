# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/knotifyconfig-6.3.0.tar.xz"
SRC_URI[sha256sum] = "ebf26f5e51e53eadb12e9a858aae9d55085d233c1f543879076452ac2900525d"

