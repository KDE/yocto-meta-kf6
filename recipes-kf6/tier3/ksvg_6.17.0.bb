# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/ksvg-6.17.0.tar.xz"
SRC_URI[sha256sum] = "3728da966932f20f190a545a7f42edea2f9bdbe6d727a5bc1b557ef5155b7f94"

