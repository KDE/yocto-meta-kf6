# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kdeclarative-6.10.0.tar.xz"
SRC_URI[sha256sum] = "db9eb2b5e615b484949e41ac5a05c5cea136e231d15a3de203902cedcdfd9e73"

