# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kservice-6.2.0.tar.xz"
SRC_URI[sha256sum] = "0646c9219c0d7d9a2371b90dc427ebc86cf30adafcb22b458f130f011de28882"

