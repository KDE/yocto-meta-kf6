# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/qqc2-desktop-style-6.11.0.tar.xz"
SRC_URI[sha256sum] = "996542716196bfac8a228a36b4618c992e193782779dcf4138d638e38306652c"

