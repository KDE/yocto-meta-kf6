# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kdav-6.1.0.tar.xz"
SRC_URI[sha256sum] = "6444d3ea581d514fb82af942d092b0bc0613a1aca2fa2313a90002d148594c2b"

