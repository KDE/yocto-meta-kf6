# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kiconthemes-6.0.0.tar.xz"
SRC_URI[sha256sum] = "f557bd269fafe617eb8d4b7ac2959609f96cce3ea8b1b3ac231063a726927bb0"

