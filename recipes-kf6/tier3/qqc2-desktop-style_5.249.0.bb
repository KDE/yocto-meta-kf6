# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/qqc2-desktop-style-5.249.0.tar.xz"
SRC_URI[sha256sum] = "90b089db5fa5f664d583638300c5b1da03e91c56dee3da000433cb5e0d731f59"

