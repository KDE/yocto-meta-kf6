# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kxmlgui-6.7.0.tar.xz"
SRC_URI[sha256sum] = "a451c16d70a591de13973079115f35905e3c42302f5c8c8ae3ec75d76a06fca1"

