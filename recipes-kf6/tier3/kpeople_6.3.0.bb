# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kpeople-6.3.0.tar.xz"
SRC_URI[sha256sum] = "967f979e56acdf546198c1950e554663c963aeec56e20405607878294772303e"

