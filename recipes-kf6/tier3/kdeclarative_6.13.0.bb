# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kdeclarative-6.13.0.tar.xz"
SRC_URI[sha256sum] = "e828e3633d8f06febd6bb1caf5dc983218e87c9fb5ab1259429b676f96b0a328"

