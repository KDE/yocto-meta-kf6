# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kded-6.8.0.tar.xz"
SRC_URI[sha256sum] = "529263fb1a97aa55828e2e0c781118700a6121df49adbed1ee56e879c8ec5121"

