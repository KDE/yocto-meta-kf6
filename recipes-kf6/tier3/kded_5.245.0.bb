# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kded-5.245.0.tar.xz"
SRC_URI[sha256sum] = "a244f9c5ae7ecea343ec849cd6d912ec0fc26a05bbde601c8e526807132596f5"

