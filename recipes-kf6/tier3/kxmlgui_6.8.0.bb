# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kxmlgui-6.8.0.tar.xz"
SRC_URI[sha256sum] = "997f310a46ec2c153010fc5967753390a99bc50621d19f926488164172c51fcc"

