# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kdav-6.10.0.tar.xz"
SRC_URI[sha256sum] = "2e8eff3e8c35001688807a97e490a6e7851a7a1a1fdf72df5559863b8612903d"

