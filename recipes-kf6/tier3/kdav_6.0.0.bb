# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kdav-6.0.0.tar.xz"
SRC_URI[sha256sum] = "b3c81f5e312b3eeed2c8b7db218f64b90f67e1b2d0ce37a44ff273b5232843e9"

