# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/baloo-5.249.0.tar.xz"
SRC_URI[sha256sum] = "508dbf05e579f9a33c553e0f2d617fe2a61f0dd51413fd8960e46ea9a92aa537"

