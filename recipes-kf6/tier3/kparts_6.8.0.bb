# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kparts-6.8.0.tar.xz"
SRC_URI[sha256sum] = "0a21d2abf4c4406015f7d5abebefec0493575847ea4ec34ea23d53db5255b327"

