# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/knewstuff-5.246.0.tar.xz"
SRC_URI[sha256sum] = "036b3237a382b37bdea1102948a0fd86db76263b58126de66f95189dc073436d"

