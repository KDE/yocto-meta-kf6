# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kiconthemes-5.245.0.tar.xz"
SRC_URI[sha256sum] = "fbcb1399668dde2b358f7213cf535da825e37db74fc02f71f04793ab875cace6"

