# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kbookmarks-5.248.0.tar.xz"
SRC_URI[sha256sum] = "dcfc4ba8273ecc6b9d8ff25fdff07b481a0974a3e45c4e2700d33a48a02becd6"

