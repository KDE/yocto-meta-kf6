# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kxmlgui-6.0.0.tar.xz"
SRC_URI[sha256sum] = "d26c62ce9f5be8643fed465531418fb67e4d13edf61797a946da301aeb9158f2"

