# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/baloo-6.13.0.tar.xz"
SRC_URI[sha256sum] = "5b4574d9a4a080bdc975e931bd411a7386a0c17ff0d5c5751dd26c92010133f8"

