# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kcmutils-5.248.0.tar.xz"
SRC_URI[sha256sum] = "7420c12f6dc638459fbb327cb48712171a04d0290d1824f081025be87afd1e14"

