# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/ksvg-6.7.0.tar.xz"
SRC_URI[sha256sum] = "bbdf7c786c959707cd9c67c04a67e51a15dbcdd6eff7ab52b03c09544e66f184"

