# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kconfigwidgets-6.0.0.tar.xz"
SRC_URI[sha256sum] = "511bed0d95de186b3cf62c7192bbb6020450d4861f05c1a545356144f17de532"

