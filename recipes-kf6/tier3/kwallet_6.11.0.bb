# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kwallet-6.11.0.tar.xz"
SRC_URI[sha256sum] = "ce94b032446ed1e1383e673185b5a4372deeab71df8b7a49083a1b6ead822e09"

