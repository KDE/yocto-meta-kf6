# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kconfigwidgets-5.249.0.tar.xz"
SRC_URI[sha256sum] = "184d748e86a57ff1c979ee8d524ab54456dee3d1c25c83b307da459e972e4c53"

