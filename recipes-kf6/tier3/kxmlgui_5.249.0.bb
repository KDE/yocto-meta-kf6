# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kxmlgui-5.249.0.tar.xz"
SRC_URI[sha256sum] = "bde8175d7dbba78f52e845dc8fea2535a06013e91f9dcf0249b14708efb66eef"

