# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kio-6.0.0.tar.xz"
SRC_URI[sha256sum] = "4951adf043299e463803cc63ed33d5261b81bff969eb189dc13350f495cb4b42"

