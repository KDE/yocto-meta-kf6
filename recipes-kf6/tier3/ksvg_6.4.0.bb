# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/ksvg-6.4.0.tar.xz"
SRC_URI[sha256sum] = "3391c74fc31526e7ff2659622d00e93b5cd8667397611d5676062e4b32d86530"

