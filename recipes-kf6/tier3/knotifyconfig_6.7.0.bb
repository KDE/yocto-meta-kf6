# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/knotifyconfig-6.7.0.tar.xz"
SRC_URI[sha256sum] = "4227da7a18f9ba83b34bf54b6d3fc168dc0726bca149d2f89585bb54ab138295"

