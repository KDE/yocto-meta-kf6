# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kconfigwidgets-5.245.0.tar.xz"
SRC_URI[sha256sum] = "0eb1abba15db658d2773dd04e6bae9d6a5d69ef9cd0b500e04e4af601efcbc8e"

