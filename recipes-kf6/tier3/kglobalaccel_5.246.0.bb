# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kglobalaccel-5.246.0.tar.xz"
SRC_URI[sha256sum] = "09374c250477bb18a1469126adb31701deded9e265f813f7b483ddf18fe3158e"

