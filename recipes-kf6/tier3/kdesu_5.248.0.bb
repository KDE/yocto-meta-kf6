# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kdesu-5.248.0.tar.xz"
SRC_URI[sha256sum] = "ddbfe6b6fe42f864976863779b37c87e5ca97930311523095378408f77ae3a92"

