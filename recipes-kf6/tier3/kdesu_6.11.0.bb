# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kdesu-6.11.0.tar.xz"
SRC_URI[sha256sum] = "aacb49d313e79f106795c4dab7de9991e6fe4e724c2b4c19deefcd171f6a3ba7"

