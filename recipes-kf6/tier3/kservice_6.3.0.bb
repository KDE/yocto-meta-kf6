# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kservice-6.3.0.tar.xz"
SRC_URI[sha256sum] = "a0564d62c1e0f2293b0dcb39cf814c2856111242b8621b33f52a70fda1a8fe54"

