# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/purpose-6.0.0.tar.xz"
SRC_URI[sha256sum] = "4fa85cbd2d9dd49216eda6433b43e05bbb114249dac51df55242328f7eb8f97c"

