# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/knewstuff-6.18.0.tar.xz"
SRC_URI[sha256sum] = "7e721735abf7e2f6f8c0f42324f885bcad1114c317ac79bfabc705fb8018dba5"

