# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/baloo-5.246.0.tar.xz"
SRC_URI[sha256sum] = "14f0018c5959a9dd8f5a7b7376a9507ac924ebfa3f37477f194d3f17059db32b"

