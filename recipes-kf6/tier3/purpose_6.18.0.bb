# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/purpose-6.18.0.tar.xz"
SRC_URI[sha256sum] = "a428e4f495658240899e02f15b7a9230e3c33069723b43e1734c21fa1a23b825"

