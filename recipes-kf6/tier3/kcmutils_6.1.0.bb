# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kcmutils-6.1.0.tar.xz"
SRC_URI[sha256sum] = "3d179b9a8ae6636ea3351e5be0414a34991a7a1f514ea492d248b68315ec2a86"

