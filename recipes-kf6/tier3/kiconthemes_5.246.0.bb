# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kiconthemes-5.246.0.tar.xz"
SRC_URI[sha256sum] = "09197263d84e5c9ac414d1c125ad327daad3ef8f7edd2c6467de82cb916daf42"

