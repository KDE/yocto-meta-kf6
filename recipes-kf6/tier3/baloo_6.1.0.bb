# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/baloo-6.1.0.tar.xz"
SRC_URI[sha256sum] = "54d821c4dc12191b3f1aeb5e753c1078c8bb46f1515d020467705d7f7c59ccaa"

