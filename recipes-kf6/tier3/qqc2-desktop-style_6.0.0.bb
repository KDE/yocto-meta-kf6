# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/qqc2-desktop-style-6.0.0.tar.xz"
SRC_URI[sha256sum] = "848305ff8880fdbad19bf57ed9f128e59cd71ecb8a36fbf920a55b60f68a2c93"

