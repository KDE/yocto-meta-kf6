# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kpeople-6.1.0.tar.xz"
SRC_URI[sha256sum] = "a5fa2e2e67b1a9ad65ec95a95201af28e20dc462e9d31007034ad4da578e1d62"

