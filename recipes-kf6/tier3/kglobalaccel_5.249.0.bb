# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kglobalaccel-5.249.0.tar.xz"
SRC_URI[sha256sum] = "714ad717d3c77c4dfbfc02ba910ec2ceabc4d07f0fd39eb6bc56ee07ff83e66c"

