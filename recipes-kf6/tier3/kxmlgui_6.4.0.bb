# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kxmlgui-6.4.0.tar.xz"
SRC_URI[sha256sum] = "04952bc7f9eaefc7a55c762d77e65888a2a71e638d3fc7126576dfe645564b0b"

