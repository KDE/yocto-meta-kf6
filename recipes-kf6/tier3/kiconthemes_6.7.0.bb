# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kiconthemes-6.7.0.tar.xz"
SRC_URI[sha256sum] = "be25bff1f5f65edd45b24ff9beda44b04c0e22d193e72458c96a5c591b70b968"

