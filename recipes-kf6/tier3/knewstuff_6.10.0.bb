# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/knewstuff-6.10.0.tar.xz"
SRC_URI[sha256sum] = "81cb5ea54fe03d27f80a481dde18a767ca1a95267403bd87483cfdd81981e4e7"

