# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kconfigwidgets-6.7.0.tar.xz"
SRC_URI[sha256sum] = "c079c67c578930baafae241bb4f252c63fdd125e44f1fb952e39bae3c9859cd1"

