# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kcmutils-5.249.0.tar.xz"
SRC_URI[sha256sum] = "4c1d37ad7bca33d3ed23e3ee5a32ec68ef7652f6d97e609dac1f5ce9c4d11e3a"

