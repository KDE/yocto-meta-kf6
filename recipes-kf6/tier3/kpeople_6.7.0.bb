# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kpeople-6.7.0.tar.xz"
SRC_URI[sha256sum] = "d36246bac50f5bf406f683fe61c92cb5e623a51de9ffed1104665e5f135ef888"

