# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kdesu-6.8.0.tar.xz"
SRC_URI[sha256sum] = "0e8a007c413faca4fa7e24382a019baecfe6b6607600ba6411c761e7bc95398f"

