# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/krunner-6.11.0.tar.xz"
SRC_URI[sha256sum] = "2179da656375d8839ea7c2c502087b527c6715e1018582ac8f63612ca527aa90"

