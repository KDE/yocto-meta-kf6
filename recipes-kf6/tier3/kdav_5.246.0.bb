# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kdav-5.246.0.tar.xz"
SRC_URI[sha256sum] = "c76e5f9327b9ada0c17388ca9bb18c81304e37d3980a2625ed5e50734df03007"

