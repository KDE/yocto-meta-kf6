# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/qqc2-desktop-style-6.17.0.tar.xz"
SRC_URI[sha256sum] = "631bd89d5c82a7f93ea26bc2079d1df81c32e75f177d3346a9cb10a9cd747797"

