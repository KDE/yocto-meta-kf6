# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kdeclarative-5.249.0.tar.xz"
SRC_URI[sha256sum] = "8392ffcab34b3a277aa143307d09b56d9c965fc7a5b95da1822d35645ee84c6e"

