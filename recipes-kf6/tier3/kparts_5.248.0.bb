# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kparts-5.248.0.tar.xz"
SRC_URI[sha256sum] = "eedba514f591ef5277e25ceada651f810895654a7773f2c8d6cf7a324976542e"

