# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kwallet-6.17.0.tar.xz"
SRC_URI[sha256sum] = "44caf691f47ba246f2efb13f9c8f7123c7e6745d4281560228b8158cc8b93d7d"

