# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kbookmarks-6.11.0.tar.xz"
SRC_URI[sha256sum] = "b5c677453c70314b9eecc0011a73103f045eabc94bc5f2f223b5979780c801c7"

