# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kxmlgui-6.17.0.tar.xz"
SRC_URI[sha256sum] = "a1807169ca2c386a8d3e25cb2b066554e49663a6e3f632f1a1968ef5476430e3"

