# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/krunner-6.8.0.tar.xz"
SRC_URI[sha256sum] = "46282c4934dfbc2d25df70b0bbf65182c30d8c39c21a3a749fe5661e3b34c3fb"

