# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/knotifyconfig-6.17.0.tar.xz"
SRC_URI[sha256sum] = "e5a08f7872ffb836fbfe9726eb86c104e30afc55996138d965731f5794981263"

