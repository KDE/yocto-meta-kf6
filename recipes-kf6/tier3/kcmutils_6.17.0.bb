# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kcmutils-6.17.0.tar.xz"
SRC_URI[sha256sum] = "8f65ef0f4f4f325ad6e2a30cb14242220f811ab1e031416fd3faa544ac683e8a"

