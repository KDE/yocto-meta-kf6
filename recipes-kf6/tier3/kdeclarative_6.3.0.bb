# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kdeclarative-6.3.0.tar.xz"
SRC_URI[sha256sum] = "807d83c487759ed54085ce514a80fb3aecea04ef98ee0ea306668fb6d5a46dce"

