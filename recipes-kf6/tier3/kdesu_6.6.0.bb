# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kdesu-6.6.0.tar.xz"
SRC_URI[sha256sum] = "d5ac127e3b218da7a785fa606490b052c09d481bcff0227b45d42ef0e3f34a5f"

