# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/knewstuff-6.6.0.tar.xz"
SRC_URI[sha256sum] = "3f927564b454c1fc1aeec05174b8f9e76303b4d9a45979d76b2188a25bd47025"

