# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kded-6.6.0.tar.xz"
SRC_URI[sha256sum] = "cc963975f80de1906e8b39970579af211138c582b1630daf280ba299b2d3f9fe"

