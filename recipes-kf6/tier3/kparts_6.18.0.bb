# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kparts-6.18.0.tar.xz"
SRC_URI[sha256sum] = "846e522e6aff2a219064a52e9baeefdfbcbea71dadb1810b9c58cb9c41821604"

