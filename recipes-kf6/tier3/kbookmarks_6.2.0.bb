# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kbookmarks-6.2.0.tar.xz"
SRC_URI[sha256sum] = "1af0d6be7c43cb17bc9a8bda464c372b9f27f99d3cdf3be95ec5f24e34368efb"

