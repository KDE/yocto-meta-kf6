# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kbookmarks-5.246.0.tar.xz"
SRC_URI[sha256sum] = "389a3e7237de9d28fc5217ee25177f0c840e79903de9c8c57a9ebb2e4f42673a"

