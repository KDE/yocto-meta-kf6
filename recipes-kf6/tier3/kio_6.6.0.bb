# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kio-6.6.0.tar.xz"
SRC_URI[sha256sum] = "977f9f076eaf249ecdd961724334326c3f3a1e7d8cfcc6ca1370f390c76a2766"

