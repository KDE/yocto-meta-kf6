# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/qqc2-desktop-style-6.18.0.tar.xz"
SRC_URI[sha256sum] = "91a60e0fefa294a337f2519c77ff2405b86eff99f3ea0e8fc3e34265ef4670f2"

