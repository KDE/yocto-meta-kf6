# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kdesu-6.2.0.tar.xz"
SRC_URI[sha256sum] = "7c612fea489d9e3e3d3c90cab0d314d98486bdc06014a60f609fdff21505822f"

