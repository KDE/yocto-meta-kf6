# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/baloo-6.10.0.tar.xz"
SRC_URI[sha256sum] = "548019740d9462d10ad862fcf801bef166365315daf73209ad86cb76e012af2a"

