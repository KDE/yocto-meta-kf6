# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/krunner-6.3.0.tar.xz"
SRC_URI[sha256sum] = "6ca6fe49c9bc0d9da3395db993bfb28d5010bcbd78b0984625819d1d3631e425"

