# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kwallet-6.8.0.tar.xz"
SRC_URI[sha256sum] = "e0b5311d88d92ca5bde4c24ae875dc3a4fc67e9319d0de2a49e25d04461e8628"

