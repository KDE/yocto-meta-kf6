# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kcmutils-6.2.0.tar.xz"
SRC_URI[sha256sum] = "8cef140ca9eabf29e88a08489c799078e85247907fd6f74165aeafd4ed40c0bb"

