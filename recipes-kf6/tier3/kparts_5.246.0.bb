# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kparts-5.246.0.tar.xz"
SRC_URI[sha256sum] = "0d41bde7867eb37566ff829065d6987fd02e7c12afd62228a648498c3a781a99"

