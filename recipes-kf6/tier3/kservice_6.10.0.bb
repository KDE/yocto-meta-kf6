# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kservice-6.10.0.tar.xz"
SRC_URI[sha256sum] = "04ad53850967e38822f8af1652b118992cd1bfa382e2718278bb6de03a0bdbb3"

