# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/qqc2-desktop-style-5.245.0.tar.xz"
SRC_URI[sha256sum] = "39d953fc3e5d1317f30d87ee3d4d14f184693ad2aba3de6c9dd9d4723c991501"

