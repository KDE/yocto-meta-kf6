# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kxmlgui-6.6.0.tar.xz"
SRC_URI[sha256sum] = "647fc7510d33b9de9196fd2c8f6f6a114dd18559ee21aab7cf47f687b8ae0452"

