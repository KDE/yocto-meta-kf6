# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kbookmarks-5.249.0.tar.xz"
SRC_URI[sha256sum] = "5cd304526ae50138c5e93652309f88a5c0b4d6702009d1b763e668ef34f57b3c"

