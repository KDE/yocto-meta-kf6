# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/ktexteditor-6.3.0.tar.xz"
SRC_URI[sha256sum] = "979dbffaeb0a0413b3745efa180aa0be6e1ed8bf8f5a938281499b931e283776"

