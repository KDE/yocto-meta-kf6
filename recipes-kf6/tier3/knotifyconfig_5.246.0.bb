# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/knotifyconfig-5.246.0.tar.xz"
SRC_URI[sha256sum] = "cacd23a5f3109dab90d1ec373ed3be71ccb302185c2accd92c46dcd4546f6af7"

