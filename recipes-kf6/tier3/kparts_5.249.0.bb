# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kparts-5.249.0.tar.xz"
SRC_URI[sha256sum] = "eb7926e2be40fb0afe4324aaa018d5da2dc687a6b4853a46c64a5b1dcd383738"

