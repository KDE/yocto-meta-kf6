# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kdav-6.4.0.tar.xz"
SRC_URI[sha256sum] = "cf428935158984443fc0736252cf2e717065b76a72e6a42864c0dbe7581038ec"

