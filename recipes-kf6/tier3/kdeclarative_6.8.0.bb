# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kdeclarative-6.8.0.tar.xz"
SRC_URI[sha256sum] = "ad461085c7bfc2ac68f1dc252c666959261efb2ffa80e7923e76b781c72336a1"

