# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kwallet-6.18.0.tar.xz"
SRC_URI[sha256sum] = "c8630e1b280b9aee44f3367302fce381370a611557f1941908b9286e3891d163"

