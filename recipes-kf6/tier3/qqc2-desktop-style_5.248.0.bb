# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/qqc2-desktop-style-5.248.0.tar.xz"
SRC_URI[sha256sum] = "7561607923c3290ee5ef0f131e513157d02cbf0a7fcc5aa308b652f234423dde"

