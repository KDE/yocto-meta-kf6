# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kparts-6.10.0.tar.xz"
SRC_URI[sha256sum] = "a3c460f635f32e254093da3d46d53fe9a4a7cca5987149047981b477c50a060c"

