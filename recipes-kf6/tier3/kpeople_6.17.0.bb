# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kpeople-6.17.0.tar.xz"
SRC_URI[sha256sum] = "dd0ec4b9baed40a2f960ce4903bdc79073f551969393314e3aa97c75f730f7bf"

