# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kdesu-6.1.0.tar.xz"
SRC_URI[sha256sum] = "a6a397e08ccd3537dc9b1329e8cc1f05ca6acf3d9c18396e4118e51446ba827e"

