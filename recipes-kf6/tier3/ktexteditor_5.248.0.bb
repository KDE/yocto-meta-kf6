# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/ktexteditor-5.248.0.tar.xz"
SRC_URI[sha256sum] = "b6dc2203148b3cc20c335c23722d320a24e72128e99d93dab8d303baaa182ffa"

