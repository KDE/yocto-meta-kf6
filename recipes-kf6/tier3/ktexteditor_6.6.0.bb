# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/ktexteditor-6.6.0.tar.xz"
SRC_URI[sha256sum] = "9991a78fd5cf692964d84210baea472ece56434d924f9e67561b857f8b48c777"

