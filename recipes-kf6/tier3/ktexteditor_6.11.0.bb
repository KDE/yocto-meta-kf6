# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/ktexteditor-6.11.0.tar.xz"
SRC_URI[sha256sum] = "82d33dccad98e2f514de4d17c4e665197fdd8588a55979358f88aeeac6fc4419"

