# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/baloo-6.3.0.tar.xz"
SRC_URI[sha256sum] = "87af96e58d9303479e628b7c801665631b6e5698e1ba9526f415cf6f3755a064"

