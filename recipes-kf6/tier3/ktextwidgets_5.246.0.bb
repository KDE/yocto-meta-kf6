# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/ktextwidgets-5.246.0.tar.xz"
SRC_URI[sha256sum] = "050151bcf7641e90cacebef2bf671b495014da1d2bd6d3f7f446624cb88e9cd3"

