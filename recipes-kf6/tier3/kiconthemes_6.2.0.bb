# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kiconthemes-6.2.0.tar.xz"
SRC_URI[sha256sum] = "c0ffe65f53f59b75bf0432c4f57f7d36b6840c87f80e9ea5b88ceb71a28b5645"

