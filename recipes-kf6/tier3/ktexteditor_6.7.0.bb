# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/ktexteditor-6.7.0.tar.xz"
SRC_URI[sha256sum] = "ed76f72324225a926e00c2c970d48d7f11a576e942e48d092e9837bda79d6991"

