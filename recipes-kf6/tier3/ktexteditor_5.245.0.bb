# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/ktexteditor-5.245.0.tar.xz"
SRC_URI[sha256sum] = "541a06c8a58409a79359185431a3abab261bbfa9080ab1162c107b36edaace18"

