# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kio-6.1.0.tar.xz"
SRC_URI[sha256sum] = "47cb00258ca38f9c1ee2aa7929f5b12bc7d99cb580da560ada71050fa089ffd2"

