# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kwallet-6.6.0.tar.xz"
SRC_URI[sha256sum] = "b319cc4cf79cc1796e7246f61bbc56bba070aa5ec994b30e11b1faa685ce7d54"

