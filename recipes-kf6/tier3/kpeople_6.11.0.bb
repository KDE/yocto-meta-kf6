# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kpeople-6.11.0.tar.xz"
SRC_URI[sha256sum] = "3f67af43442358e7b4d9a0a81d86133707ffaae0f5e05c48aa1f390ec47ff96b"

