# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kded-5.249.0.tar.xz"
SRC_URI[sha256sum] = "b0180110ee0def308de45defbd061928ad097da7d8da0278a68a2e1977e232cc"

