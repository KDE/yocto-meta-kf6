# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kio-6.11.0.tar.xz"
SRC_URI[sha256sum] = "fe511e43a5386f963c9afef93a21c0df44a2c24fcc417777e4d0569102477ff8"

