# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/ktexteditor-6.8.0.tar.xz"
SRC_URI[sha256sum] = "6a58ab74c4efddf3161174e860d211426454122e844b25fc25ef6282a1e7a270"

