# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kdeclarative-6.6.0.tar.xz"
SRC_URI[sha256sum] = "3a8a3215e5a5ae9a2e7e67b17a8feab6411d729df0367102e094c8d7a5ff58b6"

