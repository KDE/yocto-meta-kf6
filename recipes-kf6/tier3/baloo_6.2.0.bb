# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/baloo-6.2.0.tar.xz"
SRC_URI[sha256sum] = "1ea413b9dbada7d0646a1f8dc3f0688928c266e6388528cfd05d4c079a7e22a8"

