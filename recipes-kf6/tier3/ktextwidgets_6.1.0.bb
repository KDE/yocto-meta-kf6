# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/ktextwidgets-6.1.0.tar.xz"
SRC_URI[sha256sum] = "72cd44721c9209cc17bf3e8e1dccba823bcbe8156aa370205c5ce1ff746b6553"

