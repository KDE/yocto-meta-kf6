# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/knewstuff-6.0.0.tar.xz"
SRC_URI[sha256sum] = "0299dba980590bd7c74870a74c6bb6ca732af478ab2c9ba414943f62ea0be0fa"

