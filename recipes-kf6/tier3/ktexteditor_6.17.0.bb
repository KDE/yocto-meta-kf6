# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/ktexteditor-6.17.0.tar.xz"
SRC_URI[sha256sum] = "9904c0c5c933a368d6f492d9e116ccce201054d5a029b8b0fe0759ff87eb8ca3"

