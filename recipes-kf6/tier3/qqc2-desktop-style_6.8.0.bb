# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/qqc2-desktop-style-6.8.0.tar.xz"
SRC_URI[sha256sum] = "e9692f00d79b963bdcae716caab964c2534750c85d7fe02fce7a908003eb4da3"

