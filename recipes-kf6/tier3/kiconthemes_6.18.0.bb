# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kiconthemes-6.18.0.tar.xz"
SRC_URI[sha256sum] = "b971460949fafc98e7ae293f35635c2fd6101a6fc46b2f4fce64bb21440ece04"

