# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/krunner-5.249.0.tar.xz"
SRC_URI[sha256sum] = "9c7e33b3eafc4ee174c469118a48b157f97794814af1f130f405024ed364d25e"

