# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/krunner-6.6.0.tar.xz"
SRC_URI[sha256sum] = "17d4201be7ce712071d29e9528feafdc2be20391834a110c3584cc142c9f4b11"

