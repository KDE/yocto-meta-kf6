# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/ktexteditor-5.249.0.tar.xz"
SRC_URI[sha256sum] = "3375cec0d819ac7bb6f8d7358158cc75f85b06198c530d7b81e9745ab0ff53e4"

