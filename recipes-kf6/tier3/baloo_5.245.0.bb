# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/baloo-5.245.0.tar.xz"
SRC_URI[sha256sum] = "82ab7f1a343408cc441dec8f624446068b1370662676567a699884e3e51eec32"

