# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/knewstuff-6.11.0.tar.xz"
SRC_URI[sha256sum] = "8b3802b6b64309ab6709af350f248dc62e3e6d50b0db4ecb0c968acfbfb23520"

