# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kdeclarative-6.7.0.tar.xz"
SRC_URI[sha256sum] = "f1f804f6bac2b229503cfd165ebd8ae093533888ae15e0e61474c6e328d535b9"

