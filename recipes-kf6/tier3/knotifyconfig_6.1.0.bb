# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/knotifyconfig-6.1.0.tar.xz"
SRC_URI[sha256sum] = "dfe85a45500470a306df3176f665af2589521ef5090612e7a82ec618e061fe87"

