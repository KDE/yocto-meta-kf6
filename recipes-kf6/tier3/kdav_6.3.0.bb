# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kdav-6.3.0.tar.xz"
SRC_URI[sha256sum] = "b092a919e82553999578db1028f68ebfe6cb5f1da129722f2c6a662d0db729b9"

