# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kglobalaccel-5.248.0.tar.xz"
SRC_URI[sha256sum] = "4c98cc8a2f1f0f6bd487465d04a80b4b10e45693954a6dc078da5904cf7449bc"

