# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/ktextwidgets-5.245.0.tar.xz"
SRC_URI[sha256sum] = "35e76322cfa2628a70f6e4ff4ebe7a5b6d88c1cfa186deab20e30ae3b882d5cf"

