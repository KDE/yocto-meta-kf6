# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/ktexteditor-6.10.0.tar.xz"
SRC_URI[sha256sum] = "3f80c4feb8737cef83775e2c79f86060c16af89ee8b48e2d72f94bdc1a180b9f"

