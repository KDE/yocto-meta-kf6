# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kbookmarks-6.0.0.tar.xz"
SRC_URI[sha256sum] = "15b5436c3adbd517a014f33803c30bd60656bbccb9a2b2a6e46fd4e2237db9a5"

