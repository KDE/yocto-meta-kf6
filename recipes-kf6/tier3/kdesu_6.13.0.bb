# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kdesu-6.13.0.tar.xz"
SRC_URI[sha256sum] = "6be91eb21912bb2521f4e4f19267639c3bed33ab5dd09f79f279e2f94c380a62"

