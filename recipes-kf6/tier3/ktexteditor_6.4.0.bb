# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/ktexteditor-6.4.0.tar.xz"
SRC_URI[sha256sum] = "825e1a79549d66f204d50869f1dfbbc8a14ab96e76b3e8c3e899b236edccd6d4"

