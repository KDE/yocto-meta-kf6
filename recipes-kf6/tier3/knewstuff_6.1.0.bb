# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/knewstuff-6.1.0.tar.xz"
SRC_URI[sha256sum] = "1c6a076410538084021cff1eeb02be2f34280284717a34290d42b11dfe3b3d3f"

