# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/knewstuff-6.7.0.tar.xz"
SRC_URI[sha256sum] = "a4184622d430b64ec7cc4c77113df67c886f359cc89cc6313fbcc71764d23fa7"

