# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/purpose-5.248.0.tar.xz"
SRC_URI[sha256sum] = "dd887c8533a38ff0dce4b31ca79479e36866811b8931d50c320842aa11d49bd6"

