# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/ktextwidgets-6.13.0.tar.xz"
SRC_URI[sha256sum] = "1ff29bf02b247f09ffaaafe4578f0977b51c42b67eef84fddb5677dd7d1edf2e"

