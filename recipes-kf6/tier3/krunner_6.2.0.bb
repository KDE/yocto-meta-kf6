# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/krunner-6.2.0.tar.xz"
SRC_URI[sha256sum] = "f18f1578ff8c76c455837a4bc9a3e71273bba4ac54afd24e143a9dc20706041f"

