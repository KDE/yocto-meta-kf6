# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kxmlgui-6.18.0.tar.xz"
SRC_URI[sha256sum] = "6d5e240c835668419ac036666fa4c99e3479795c6988100763f810ca8835c401"

