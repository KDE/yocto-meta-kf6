# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kconfigwidgets-6.4.0.tar.xz"
SRC_URI[sha256sum] = "98f7e9e11557d2d1db59711052a3b4cb4f8572316eff6421459b90b5d4393983"

