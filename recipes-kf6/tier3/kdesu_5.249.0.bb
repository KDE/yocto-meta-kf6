# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kdesu-5.249.0.tar.xz"
SRC_URI[sha256sum] = "5cf3ac1eed0fb1575bbcf5ed36f4001ad65f0aff4ed6652b8aa1f586ddbb20e0"

