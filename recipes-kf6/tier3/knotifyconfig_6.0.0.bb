# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/knotifyconfig-6.0.0.tar.xz"
SRC_URI[sha256sum] = "323fe757a01ecb2481d9ad04b0902efd3dde13cb1fc044ee1ac1b7f5a29369e6"

