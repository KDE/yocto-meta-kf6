# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/ktextwidgets-6.6.0.tar.xz"
SRC_URI[sha256sum] = "805dff320b75a62316fe50aa33eedb355c1e2db36d00b58c39fc36ce6bfd8988"

