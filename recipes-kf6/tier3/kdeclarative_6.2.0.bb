# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kdeclarative-6.2.0.tar.xz"
SRC_URI[sha256sum] = "a85c3f1599d229f052ee3786e9041ace5510c99844c8efc7bfc9ddaed1936d84"

