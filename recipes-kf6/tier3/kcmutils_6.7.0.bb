# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kcmutils-6.7.0.tar.xz"
SRC_URI[sha256sum] = "4118388f8f62aa5f1139ed78823b58b009e9ebf7f3755e9a94ab5f9eba644cbe"

