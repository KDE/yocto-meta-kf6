# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kded-6.7.0.tar.xz"
SRC_URI[sha256sum] = "22aa1b6543b40e094346138516131c0f7eb78a70e87296938457fd1386680a2f"

