# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/purpose-6.13.0.tar.xz"
SRC_URI[sha256sum] = "2bab74907505bee95faacdc9c93e8a94b2ab33651a97d2ae7d63fd483f458327"

