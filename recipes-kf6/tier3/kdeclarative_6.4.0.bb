# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kdeclarative-6.4.0.tar.xz"
SRC_URI[sha256sum] = "bb47b521a4c843f6b3de78d46fe430de15886598c6d89d39bd91c767f40f6a85"

