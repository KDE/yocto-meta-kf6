# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/krunner-5.246.0.tar.xz"
SRC_URI[sha256sum] = "912f1af9c2577357093f7b3c02c48f52b694ab209fc77ab5f200a02943098a6c"

