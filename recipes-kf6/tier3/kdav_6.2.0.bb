# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kdav-6.2.0.tar.xz"
SRC_URI[sha256sum] = "f18278cfc72b7a8eed48a4d447eae07e431d14298dbcf59ba45bb936286c64e1"

