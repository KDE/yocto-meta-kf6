# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/baloo-5.248.0.tar.xz"
SRC_URI[sha256sum] = "9d8a8ae38226a5ff9d71dbc8f725fcc29b11719902e29ffc46615ae5a8636adb"

