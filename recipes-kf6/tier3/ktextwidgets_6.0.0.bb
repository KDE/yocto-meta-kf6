# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/ktextwidgets-6.0.0.tar.xz"
SRC_URI[sha256sum] = "b093f570ea3c2d4320e41b575a540fb75acd5b5f818bc6215a5fdb57754b6c40"

