# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kcmutils-6.0.0.tar.xz"
SRC_URI[sha256sum] = "9b09b140c013d568a2ee357f824bfb64145e4dfdd1689da6fbfb4f418c5ba43b"

