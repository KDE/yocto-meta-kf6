# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/purpose-6.6.0.tar.xz"
SRC_URI[sha256sum] = "d02c70c3d122eda4739e8716f05c9bb7370751d06730d8e23d1cf4266d00c2d2"

