# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kconfigwidgets-5.248.0.tar.xz"
SRC_URI[sha256sum] = "779e03880eb5cc9d1d6207c1de9a2f144ef103ea296e7b86b89de3e480391bc8"

