# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kdesu-6.17.0.tar.xz"
SRC_URI[sha256sum] = "666899ad546b7bd002e3fc1697032f8920ce7261df2ef519e81d4aae91971123"

