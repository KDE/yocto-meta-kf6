# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/ktexteditor-6.13.0.tar.xz"
SRC_URI[sha256sum] = "7c12ef061f45bdc3b5ecc5c0eec9089cd6521c499217de07a273dc65fdd7c7cf"

