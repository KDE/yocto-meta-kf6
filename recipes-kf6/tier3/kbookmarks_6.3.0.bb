# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kbookmarks-6.3.0.tar.xz"
SRC_URI[sha256sum] = "f0789daaab86b0c2451a91e21327f20bf1d200491cf7744af93c262aa76cfea1"

