# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/purpose-6.1.0.tar.xz"
SRC_URI[sha256sum] = "4612fff4ce512796422f4bde3efa8f5ff63f96b8b7d92e48f87f96c89e21198e"

