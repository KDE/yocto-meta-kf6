# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kxmlgui-5.248.0.tar.xz"
SRC_URI[sha256sum] = "c427df029924474f122ad665b26ee86584dbcb5169c0b6e477ded8017f192c77"

