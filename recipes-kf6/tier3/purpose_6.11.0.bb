# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/purpose-6.11.0.tar.xz"
SRC_URI[sha256sum] = "48e172f05869e1a2cc19e0eb6230ae12cfe23d234b40d6d3bb2f411c7f6984e0"

