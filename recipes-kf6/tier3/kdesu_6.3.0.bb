# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kdesu-6.3.0.tar.xz"
SRC_URI[sha256sum] = "a39905a1813347777907622063fc3d515a20c3b6da0fe479aa61734126a9e7de"

