# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kbookmarks-5.245.0.tar.xz"
SRC_URI[sha256sum] = "52fdbdfb8efbe71799cb01e08b18693d47d7102a9b03c1ac75aeaddc6348907c"

