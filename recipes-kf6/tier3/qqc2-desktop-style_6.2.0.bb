# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/qqc2-desktop-style-6.2.0.tar.xz"
SRC_URI[sha256sum] = "b8ed270d930aad05eadf1ec5a540870f1128d8c728d8616c40801d6980869b1c"

