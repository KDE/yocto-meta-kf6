# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/krunner-6.0.0.tar.xz"
SRC_URI[sha256sum] = "22d33fd27567a350ae4edae4fe5662b748e8fabd539863441794558e68f3313d"

