# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kio-6.18.0.tar.xz"
SRC_URI[sha256sum] = "a97acec1407e1f00ca74e63964e7608828d4431bfe0aebe9010c296bb6387bda"

