# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/knewstuff-5.245.0.tar.xz"
SRC_URI[sha256sum] = "bc841cedd8249f6dc5aef87c3035a279c770df2da2a85f7631bd197c7af87e9d"

