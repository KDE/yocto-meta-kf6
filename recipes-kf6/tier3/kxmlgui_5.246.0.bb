# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kxmlgui-5.246.0.tar.xz"
SRC_URI[sha256sum] = "dccaadc94d6b3b4c5f13fb94ee5406d393d93e50ff441cdf9cd715acf052adb5"

