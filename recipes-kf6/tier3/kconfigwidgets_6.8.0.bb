# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kconfigwidgets-6.8.0.tar.xz"
SRC_URI[sha256sum] = "9dc3a82f1fb32750e6ecf78a863a43226a30e2fcadd7551eec7886916e1cb4f1"

