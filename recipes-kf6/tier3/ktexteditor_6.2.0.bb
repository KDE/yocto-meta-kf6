# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/ktexteditor-6.2.0.tar.xz"
SRC_URI[sha256sum] = "c10a5e4cc921aeb51b17e97d4f29883ab186b63d108199e6a319440a39f1f2a0"

