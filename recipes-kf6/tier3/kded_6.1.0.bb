# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kded-6.1.0.tar.xz"
SRC_URI[sha256sum] = "b18d0ef236995c19da926e5ba3f248689850ffde660eb86b18ab68e87b119ba1"

