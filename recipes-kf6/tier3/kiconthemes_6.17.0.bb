# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kiconthemes-6.17.0.tar.xz"
SRC_URI[sha256sum] = "5cf0b20628d300447770c4ab00edb225ecc85561792923ec0083f9bc9e0b4247"

