# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/qqc2-desktop-style-6.6.0.tar.xz"
SRC_URI[sha256sum] = "a82361a7b206b94a784ee9b919276ef733fb694710a1505af9a71db70832eb62"

