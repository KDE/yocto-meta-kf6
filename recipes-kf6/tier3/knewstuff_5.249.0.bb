# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/knewstuff-5.249.0.tar.xz"
SRC_URI[sha256sum] = "75fb94126360f52d6f4a72437281b9e15941946e1a1e64f03028bcabb6a1eeb0"

