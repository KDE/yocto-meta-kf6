# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kio-5.245.0.tar.xz"
SRC_URI[sha256sum] = "5be091d541cb9308a5a104012deccb1c7f55e4479f5fb42c592509b68224cefe"

