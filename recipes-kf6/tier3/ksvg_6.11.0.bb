# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/ksvg-6.11.0.tar.xz"
SRC_URI[sha256sum] = "053092e36b76deeffe19629ae12a372b172f947bee3cc2034c68e7ba4e1da6cf"

