# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kdesu-6.7.0.tar.xz"
SRC_URI[sha256sum] = "41091ea45c6e22e1411d89d1538b2c8bd98bdc1f38d59df3e9c423aac0224e28"

