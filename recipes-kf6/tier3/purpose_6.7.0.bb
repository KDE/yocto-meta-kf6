# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/purpose-6.7.0.tar.xz"
SRC_URI[sha256sum] = "4f8bbf19022c70df1dc345a4abd81677a505a2e8fef643311287fe8e9212d56a"

