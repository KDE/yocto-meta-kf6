# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kiconthemes-5.249.0.tar.xz"
SRC_URI[sha256sum] = "dc18ef7d2b8ca5e2512a5ef69ee344ab1dec5e2654a5b55ac2add77a09f8b737"

