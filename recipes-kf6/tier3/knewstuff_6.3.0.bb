# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/knewstuff-6.3.0.tar.xz"
SRC_URI[sha256sum] = "a16d16b22e94cb5159a3b1a071c5785729e3052baf9e33f2ab020b9032d967d7"

