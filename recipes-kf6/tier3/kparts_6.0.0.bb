# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kparts-6.0.0.tar.xz"
SRC_URI[sha256sum] = "f08308556eecd6db0be727ec1d27b3bb533880a530d112bb16ec2f08ead1f6e1"

