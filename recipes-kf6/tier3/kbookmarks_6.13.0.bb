# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kbookmarks-6.13.0.tar.xz"
SRC_URI[sha256sum] = "6b1d53d48e3a8d2daf8335f105c3389f99708be46ff7cc02dee5d590e66db2d2"

