# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kdesu-6.18.0.tar.xz"
SRC_URI[sha256sum] = "3203b047113cf08bca3981ede657e45b417a7cd0f2879bb4f9e901ad4e594616"

