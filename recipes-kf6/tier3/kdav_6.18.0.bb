# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kdav-6.18.0.tar.xz"
SRC_URI[sha256sum] = "c3f048d7ca9f094647bb687f1ea218ba00bf3ab3b07a3d1abbc29dad677c5526"

