# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kconfigwidgets-6.2.0.tar.xz"
SRC_URI[sha256sum] = "3b5e72c6e55e7b9d0b3ebee0fe8b39c098dd07a56de39da1556891925eb7d963"

