# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kservice-6.8.0.tar.xz"
SRC_URI[sha256sum] = "23096cf23ee3f262609c093f36c90c139350eab1d132132e0bfc02ad8b818128"

