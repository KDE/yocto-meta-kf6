# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/knewstuff-5.248.0.tar.xz"
SRC_URI[sha256sum] = "09fc01ee3b42a5ba816a608315e7381410575263a3112bcd63ef39eb28b49e37"

