# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kio-6.7.0.tar.xz"
SRC_URI[sha256sum] = "df235019a07acd579920f6c655050e02dacf847c706f4b8279e755be46f9d990"

