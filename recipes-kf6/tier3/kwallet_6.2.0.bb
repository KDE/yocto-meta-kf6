# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kwallet-6.2.0.tar.xz"
SRC_URI[sha256sum] = "2e58119a6442cb00e3014f01636e872337cff362ec1ef120caf2ba01813bd2c1"

