# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/purpose-6.8.0.tar.xz"
SRC_URI[sha256sum] = "7ee8182651251c8280a7df6288d3f625769dcd8b4a6d4fee7efe56995435f06a"

