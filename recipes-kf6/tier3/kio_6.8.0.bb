# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kio-6.8.0.tar.xz"
SRC_URI[sha256sum] = "cb8ac25a5324e8b617817feefcdf7739eb20dc35dcf4444b886c1dcbb99a56be"

