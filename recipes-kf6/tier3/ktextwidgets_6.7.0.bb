# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/ktextwidgets-6.7.0.tar.xz"
SRC_URI[sha256sum] = "23bb71450e39f437c06bd9af48e7893253c31ad10649b0901d0a8ec1ee18ae01"

