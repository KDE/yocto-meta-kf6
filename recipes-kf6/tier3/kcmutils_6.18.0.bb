# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kcmutils-6.18.0.tar.xz"
SRC_URI[sha256sum] = "6114c1ec8eb73734619a99e4956dce449828af336c2cd91d19bfeb03e221528f"

