# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/knewstuff-6.17.0.tar.xz"
SRC_URI[sha256sum] = "1059cb7cdb9ba8170de82a08c6833490007a152a46e4bdbe24304eeddc263d66"

