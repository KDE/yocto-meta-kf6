# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kdav-6.8.0.tar.xz"
SRC_URI[sha256sum] = "d895e3b6d4ff9916d185ec50f94b08a70636202e28739fcc74772e2ecd92182c"

