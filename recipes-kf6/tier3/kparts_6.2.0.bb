# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kparts-6.2.0.tar.xz"
SRC_URI[sha256sum] = "04f70829abc7033327f42e5e5ee1365f4dba9968b184f34212c5486e36a9beb1"

