# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kxmlgui-6.10.0.tar.xz"
SRC_URI[sha256sum] = "561fa755638da16cae204b670f62fab70156b9121b9313612238ca9c9e8e1292"

