# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kdeclarative-6.1.0.tar.xz"
SRC_URI[sha256sum] = "f94138d62e17355812f37613aa936fad2e5140fe4f09a9e42e4d9bfa9881c702"

