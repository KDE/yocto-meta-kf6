# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kpeople-5.248.0.tar.xz"
SRC_URI[sha256sum] = "78c584b87b9cb87800dd26f4737583320b0b8d7b56b0ac43c247313721d3f974"

