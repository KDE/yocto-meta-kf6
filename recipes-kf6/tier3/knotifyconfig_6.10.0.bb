# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/knotifyconfig-6.10.0.tar.xz"
SRC_URI[sha256sum] = "f0ba447a58edefd8302905ed88030291990e273eded97d11d2b7de986a35d05c"

