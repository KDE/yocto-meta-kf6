# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/ksvg-6.18.0.tar.xz"
SRC_URI[sha256sum] = "0eab2ba532906b612afee2fbfa802a88d7f4570d4c322972cb6debd320075c10"

