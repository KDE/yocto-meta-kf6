# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kconfigwidgets-6.18.0.tar.xz"
SRC_URI[sha256sum] = "aa5a7be6278a19733f77e6a435f84c3e71926b28f1ac3766313778890d640813"

