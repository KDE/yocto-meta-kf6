# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/ktextwidgets-5.249.0.tar.xz"
SRC_URI[sha256sum] = "8f9ffdcf33ab8bf696c5c2a42cdc4cc55f697277629ddaecb0057b0ee8e32470"

