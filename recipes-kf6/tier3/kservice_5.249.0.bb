# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kservice-5.249.0.tar.xz"
SRC_URI[sha256sum] = "4e42781819886a372ce5b1587a77ce3374dec298c3d185d18a6a62a7817f198c"

