# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kiconthemes-6.13.0.tar.xz"
SRC_URI[sha256sum] = "a3278c5d29c2fdb0ef5dd72a0d5f9b5a75c072663026e1e4fdbb27f51bfa5aa1"

