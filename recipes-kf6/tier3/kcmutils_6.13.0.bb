# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kcmutils-6.13.0.tar.xz"
SRC_URI[sha256sum] = "11f0323b8db9d21517962af0ffbbef5ba3f93c0f119881ded08be9400dc15c8f"

