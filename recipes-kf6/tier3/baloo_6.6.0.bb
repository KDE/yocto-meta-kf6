# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/baloo-6.6.0.tar.xz"
SRC_URI[sha256sum] = "7b097526d1c8c90cdb8126a941ff4e159f800fcfff6f812668373d7b9b5bb719"

