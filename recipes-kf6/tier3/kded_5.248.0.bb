# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kded-5.248.0.tar.xz"
SRC_URI[sha256sum] = "755b283d18d2d9d4ba46dc5a05f7ee5bb6952bb3bc18db5b5b3b150424afdef6"

