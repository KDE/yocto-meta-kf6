# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kdeclarative-5.246.0.tar.xz"
SRC_URI[sha256sum] = "0eb16a988cea5b95a21a8d328f5e9a293b01132a3d16aab3da7bfea0573b2737"

