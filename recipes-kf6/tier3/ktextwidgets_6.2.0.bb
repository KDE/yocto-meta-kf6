# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/ktextwidgets-6.2.0.tar.xz"
SRC_URI[sha256sum] = "469368c341265865e2562ab6d3be754db96896280bdca90c134127b1501ab5ed"

