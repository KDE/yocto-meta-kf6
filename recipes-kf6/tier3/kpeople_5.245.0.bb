# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kpeople-5.245.0.tar.xz"
SRC_URI[sha256sum] = "4ee6c9f4516b7092c51fbdda2e627a2e9c88726b8e61ec825ee1a78cd8a3757b"

