# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kparts-6.13.0.tar.xz"
SRC_URI[sha256sum] = "c8d336fab4d37b096bc9f0fff2d0a6ef25394059bc87fca93b00ea6b29e33df4"

