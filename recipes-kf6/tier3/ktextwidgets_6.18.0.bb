# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/ktextwidgets-6.18.0.tar.xz"
SRC_URI[sha256sum] = "9afb136806e8b95c34211e1dae66e4cf14d7aac2ab244d5264caac4e823d8edf"

