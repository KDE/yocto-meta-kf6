# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kwallet-6.1.0.tar.xz"
SRC_URI[sha256sum] = "cf92adbbdfe7643a4e0f93a8d229626fb859fe903d0b4b5841ad114175b84613"

