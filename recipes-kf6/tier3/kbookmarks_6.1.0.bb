# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kbookmarks-6.1.0.tar.xz"
SRC_URI[sha256sum] = "b763563217c1e3e84834b4b7779891c4512e8fd27cb2b53af00a2ab7612d4747"

