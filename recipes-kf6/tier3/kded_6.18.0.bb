# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kded-6.18.0.tar.xz"
SRC_URI[sha256sum] = "c90e3ee6bf991f320ac428b2c126afbfe1130a74eee6724058105883072e5882"

