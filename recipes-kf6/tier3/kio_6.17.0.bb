# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kio-6.17.0.tar.xz"
SRC_URI[sha256sum] = "d00d4952198f8e9ff44335b340714615e0124857edbd67c4964b50e0c913d62d"

