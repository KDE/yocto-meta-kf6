# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kservice-6.13.0.tar.xz"
SRC_URI[sha256sum] = "65d9542f729d30be3dcc12aa2ebeb50238ce4d30a850775f9b006b9b9f1c1cd5"

