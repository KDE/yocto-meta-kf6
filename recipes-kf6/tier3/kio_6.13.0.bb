# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kio-6.13.0.tar.xz"
SRC_URI[sha256sum] = "431552d0b740f357c4db7de2e28dcf0ec28e2bfb041a042da5708ae26ec2a203"

