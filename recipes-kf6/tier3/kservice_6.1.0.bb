# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kservice-6.1.0.tar.xz"
SRC_URI[sha256sum] = "ee2ee7fde2c47955890876f890a0d16792f29b0cc74fd296ccab153d8b5ce781"

