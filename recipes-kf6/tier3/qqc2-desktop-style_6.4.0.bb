# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/qqc2-desktop-style-6.4.0.tar.xz"
SRC_URI[sha256sum] = "9b133056638a11b998883edff0d9078e868c09725868bdaee8e733fde308f0fb"

