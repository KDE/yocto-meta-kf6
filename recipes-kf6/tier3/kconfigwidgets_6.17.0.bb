# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kconfigwidgets-6.17.0.tar.xz"
SRC_URI[sha256sum] = "0bc5366d38dcbe12aea32aa84e77e9c278d3c63aeed6f509af52848a30a41e21"

