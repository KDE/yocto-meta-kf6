# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kiconthemes-6.10.0.tar.xz"
SRC_URI[sha256sum] = "15807e785183c048810af0141b3a560085f2bbf00f3a21fe962eb37a673f9314"

