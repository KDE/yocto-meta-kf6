# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/knotifyconfig-6.2.0.tar.xz"
SRC_URI[sha256sum] = "b5bfec4582bc22f0c87c70fdd25a05e145fdfe5e4a60a963f512571e03d37ccc"

