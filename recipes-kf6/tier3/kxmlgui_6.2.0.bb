# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kxmlgui-6.2.0.tar.xz"
SRC_URI[sha256sum] = "ff22a79fca2737e33c5463d87fad2b46920c8d48c6583268a9ae27097a8ac902"

