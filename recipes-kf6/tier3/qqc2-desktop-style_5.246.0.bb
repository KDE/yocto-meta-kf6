# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/qqc2-desktop-style-5.246.0.tar.xz"
SRC_URI[sha256sum] = "f77c86bad4963546ef82d4bbab4ab37dd6d8f119ba85e77e53b51bc28b55e7ca"

