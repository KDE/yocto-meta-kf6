# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kcmutils-5.246.0.tar.xz"
SRC_URI[sha256sum] = "a40dee08bdcbec360befd977b5f4b8e1502c83d9657c56b66492cb9975543cd0"

