# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/purpose-6.3.0.tar.xz"
SRC_URI[sha256sum] = "bf296f6646bdcfef4aebba4d04ec03e7e72a545552b9b765a8fbfc625ee6ec17"

