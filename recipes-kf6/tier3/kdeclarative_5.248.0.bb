# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kdeclarative-5.248.0.tar.xz"
SRC_URI[sha256sum] = "c5636eb35b20fa32da85a3ee6fc13767c1463f4123c3d8fb537e7980d768d518"

