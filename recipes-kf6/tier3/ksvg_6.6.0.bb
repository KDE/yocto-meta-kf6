# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/ksvg-6.6.0.tar.xz"
SRC_URI[sha256sum] = "fd574866b6879809ecfd24f9d92c7ce51aadb91527e51d1f7c67dec8647d8ac6"

