# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/knotifyconfig-6.4.0.tar.xz"
SRC_URI[sha256sum] = "d8ef414b68c09a649f2f89d42d142b07967ce597b66fbb3f85dd02223c3cf278"

