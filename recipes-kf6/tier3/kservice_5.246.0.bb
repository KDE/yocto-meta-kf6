# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kservice-5.246.0.tar.xz"
SRC_URI[sha256sum] = "2ae01b8d6a0baa2504c5f7697c59280560a88e2af7f5e8d27fe4065f8531c560"

