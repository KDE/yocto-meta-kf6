# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kconfigwidgets-6.6.0.tar.xz"
SRC_URI[sha256sum] = "83b141867609a8e63e3cbe874e519f2d3d8a53ff7dce958b8157c697d5cc5872"

