# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/purpose-6.4.0.tar.xz"
SRC_URI[sha256sum] = "318169f201548eaa3c8a76e6eb00d9b10f51872d7f91c7f9749fcb518699e50e"

