# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kconfigwidgets-6.13.0.tar.xz"
SRC_URI[sha256sum] = "c5df55d73b116fe566863cc3b90bd4edfd5c4989f121ecfd8e0c1f7c8e40365a"

