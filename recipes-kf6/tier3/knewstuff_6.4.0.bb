# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/knewstuff-6.4.0.tar.xz"
SRC_URI[sha256sum] = "aef6f5085adec31dc09f073f3884935156f7f9276cc8e7a1b1d846c39cd8126f"

