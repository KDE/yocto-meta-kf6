# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kparts-6.1.0.tar.xz"
SRC_URI[sha256sum] = "dfca27e3d4fe7fa7038cbad3d3a0a955c570bd73b5bc0aceb3900e071495101d"

