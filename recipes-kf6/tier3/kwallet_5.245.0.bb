# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kwallet-5.245.0.tar.xz"
SRC_URI[sha256sum] = "52eb887a2fed59dd9a1e828c31ae7851ae6e30df050e7027bcae1bc408c4b1c2"

