# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kdav-6.13.0.tar.xz"
SRC_URI[sha256sum] = "d767e8f5158d7f4c1f588f17286177145880d80cfb2e215f554a6c820f86b0d9"

