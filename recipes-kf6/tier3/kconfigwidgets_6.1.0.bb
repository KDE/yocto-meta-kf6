# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kconfigwidgets-6.1.0.tar.xz"
SRC_URI[sha256sum] = "0b252b2e796ff6f05e94ab92130fe739e4fe698c223230be936b579e9df9d171"

