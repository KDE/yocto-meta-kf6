# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/krunner-6.18.0.tar.xz"
SRC_URI[sha256sum] = "69a20b4e554d8763ef4a52978e46056b598efb8ec584ac7be5bf06ca318db51c"

