# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kconfigwidgets-5.246.0.tar.xz"
SRC_URI[sha256sum] = "c8614f2117212d396c62d22b70aa7628f51831c14ddbd80f4dfa32e71c2124f5"

