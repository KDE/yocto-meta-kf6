# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kservice-6.17.0.tar.xz"
SRC_URI[sha256sum] = "b014697ea3ba359f46a6e9cf950d7bbd7a9cf09e95b36718c36b6605a9424aee"

