# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kio-5.249.0.tar.xz"
SRC_URI[sha256sum] = "0d9661b3109c4f705f612ef91494c12bcee58e46e38db1506bd2503594448ee0"

