# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kbookmarks-6.17.0.tar.xz"
SRC_URI[sha256sum] = "041b9667d3d4851b0e6fa62a9fc112a9938a487b4ca520eedde1b535636217f2"

