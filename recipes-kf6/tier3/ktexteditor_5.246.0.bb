# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/ktexteditor-5.246.0.tar.xz"
SRC_URI[sha256sum] = "fb4b175bd5835709bf7e7a56eea0ae5d789f415f5a9c7fe146b4b105072c61a6"

