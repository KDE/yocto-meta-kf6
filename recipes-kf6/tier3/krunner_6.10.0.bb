# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/krunner-6.10.0.tar.xz"
SRC_URI[sha256sum] = "459c97ad510c3565d4547b51c4dbaf19b3834c0afdf77bf6ee4dff346957d62b"

