# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kiconthemes-6.8.0.tar.xz"
SRC_URI[sha256sum] = "cc5e116abbd81000d21d875f79e586af050b31a17933bd2064b210043714cdaa"

