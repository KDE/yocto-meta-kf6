# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/krunner-6.4.0.tar.xz"
SRC_URI[sha256sum] = "aac498f1d313bfc1a8388ff47617e68c50413da15a744a38a05c473378316fbc"

