# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kbookmarks-6.4.0.tar.xz"
SRC_URI[sha256sum] = "13c72b0c47e333ada60a4665af7829910f5c83dd6ed57789fa3229ca68ad3280"

