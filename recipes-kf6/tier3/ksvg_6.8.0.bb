# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/ksvg-6.8.0.tar.xz"
SRC_URI[sha256sum] = "fe65b0852d74ac73ba4b597fe352e91bf74cf61ffff8046a1bd511c8a85084e3"

