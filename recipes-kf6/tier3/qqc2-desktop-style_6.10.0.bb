# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/qqc2-desktop-style-6.10.0.tar.xz"
SRC_URI[sha256sum] = "9e19540f8fa7d0e6a1ffb1c353a24e8c7f8e2b37a8594393af7a4d5d9e0e8e51"

