# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kpeople-6.13.0.tar.xz"
SRC_URI[sha256sum] = "3aec1ca111ef21c7927170a00d20e971b5b195b19a87df18a3ae5cb9687cf804"

