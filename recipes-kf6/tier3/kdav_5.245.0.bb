# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kdav-5.245.0.tar.xz"
SRC_URI[sha256sum] = "c62a0239a18492ff256309e0f31e46176942b85caa70615bccc9cb4b7a9b73e8"

