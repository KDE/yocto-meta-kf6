# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kwallet-5.246.0.tar.xz"
SRC_URI[sha256sum] = "d54ac4b1a4a6e4c056b3d7fbb733d873f51860d38bd296efcd73860c9b93fc80"

