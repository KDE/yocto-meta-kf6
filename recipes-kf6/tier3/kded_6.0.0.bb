# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kded-6.0.0.tar.xz"
SRC_URI[sha256sum] = "c6243233f2827b27b1a42987a7a3058f13853f7d0e2bf289c055f245d0c5c625"

