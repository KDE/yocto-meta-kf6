# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kiconthemes-6.3.0.tar.xz"
SRC_URI[sha256sum] = "945394afc9f8207924bf07f9a6de3bee7fcd523bce87e0004d62767ab37cc303"

