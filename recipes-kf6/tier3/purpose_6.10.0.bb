# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/purpose-6.10.0.tar.xz"
SRC_URI[sha256sum] = "19de7943df772c1b5ce2771099a17536e97e7ff6c5a5411c1346c25b24e51a57"

