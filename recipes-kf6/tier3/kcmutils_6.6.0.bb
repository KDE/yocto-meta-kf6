# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kcmutils-6.6.0.tar.xz"
SRC_URI[sha256sum] = "8f1b9f26ce7b055cec46a9521eab75f910ae9c395aada88d6d82cf395459b270"

