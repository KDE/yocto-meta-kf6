# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/knotifyconfig-6.13.0.tar.xz"
SRC_URI[sha256sum] = "ab9b39ebfc1de82f8aabc3a441afed730202a33d72828308eadc81232ef839b4"

