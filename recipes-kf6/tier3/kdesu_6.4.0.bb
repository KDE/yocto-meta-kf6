# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kdesu-6.4.0.tar.xz"
SRC_URI[sha256sum] = "f27ae587eb5f93bb1890b414ee3eb63b25404f96f6dbd0048426b60e0acacb5a"

