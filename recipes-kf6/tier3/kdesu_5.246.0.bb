# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kdesu-5.246.0.tar.xz"
SRC_URI[sha256sum] = "7b2b5e1008dd5b0c827b72eb3a47383edb5ebd963abdc2480130cc62a2994b2a"

