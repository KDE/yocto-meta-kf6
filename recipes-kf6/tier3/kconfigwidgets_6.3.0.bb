# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kconfigwidgets-6.3.0.tar.xz"
SRC_URI[sha256sum] = "bac86669b83c39fa0d3d45804202ed6db5aa48edc6b4d177c572a2214d262090"

