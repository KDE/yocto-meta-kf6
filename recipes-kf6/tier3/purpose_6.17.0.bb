# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/purpose-6.17.0.tar.xz"
SRC_URI[sha256sum] = "689565d5eb0999e1ccd92e8f841fc8241ab02489ca6c339f48d541b5ba93764a"

