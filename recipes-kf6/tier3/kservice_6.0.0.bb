# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/kservice-6.0.0.tar.xz"
SRC_URI[sha256sum] = "9b44acf51d280deaa3114ec59518a6af5d645cb1ec2ebadb5de74681c8891bfe"

