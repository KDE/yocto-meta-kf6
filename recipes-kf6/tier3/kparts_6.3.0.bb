# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kparts-6.3.0.tar.xz"
SRC_URI[sha256sum] = "42fc276673f499889d5713d8a9c061c7f7a76885141f214d7f12f9e58ca50400"

