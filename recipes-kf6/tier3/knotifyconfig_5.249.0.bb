# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/knotifyconfig-5.249.0.tar.xz"
SRC_URI[sha256sum] = "663ba356121da4acc0a3a782e8e05b08cdaceda3e12e3a66e4c7d89878144aa8"

