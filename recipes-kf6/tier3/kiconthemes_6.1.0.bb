# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/kiconthemes-6.1.0.tar.xz"
SRC_URI[sha256sum] = "79ce77701d4194796e2c255008f19071460aa03ff208a2117fc4e4c9310c3402"

