# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kparts-5.245.0.tar.xz"
SRC_URI[sha256sum] = "b07a42602ce91ed65e30743f45cf3a036a5b1de60321dcbfbe937b2f65c2fc39"

