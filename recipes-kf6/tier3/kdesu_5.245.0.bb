# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kdesu-5.245.0.tar.xz"
SRC_URI[sha256sum] = "677759b8d253a4773bd5dc88dc14c8323ba7dc43f0bf45008c004e9f78d4bdd2"

