# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kbookmarks-6.18.0.tar.xz"
SRC_URI[sha256sum] = "41a845ffd9effb8d942d04d76fc3a58b0bf23d3fd36aeba21c89ab9eb0fc4f85"

