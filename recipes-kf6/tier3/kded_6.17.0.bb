# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.17/kded-6.17.0.tar.xz"
SRC_URI[sha256sum] = "4f5f04b9dbcf3a0ba42815419d969b01a6624024d14994d540a973a6371cf277"

