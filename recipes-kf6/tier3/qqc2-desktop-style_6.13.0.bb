# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/qqc2-desktop-style-6.13.0.tar.xz"
SRC_URI[sha256sum] = "a8a5a8ce343ea77cb1d0b300c12e86829c913e036c6ff8ad5d21b8f96218426a"

