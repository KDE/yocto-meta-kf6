# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/ktextwidgets-6.11.0.tar.xz"
SRC_URI[sha256sum] = "0f043b8a60698ccdb88e3d6957b5f5c97cfe793ea2eea421fc467fffdf200697"

