# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kdeclarative-5.245.0.tar.xz"
SRC_URI[sha256sum] = "0c371dff4ac2f4c95bddef4777cb08201b06eb27834a56726993a378e0350da6"

