# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/ksvg-6.13.0.tar.xz"
SRC_URI[sha256sum] = "9bf0d2a7626557b43c50821bab7d1960a73f8eb981ea892a64cb4a11277ed24b"

