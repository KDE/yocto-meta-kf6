# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/baloo-6.8.0.tar.xz"
SRC_URI[sha256sum] = "59a59697e7d2bec50daa83de5268775bde77cf98351277d0f4ac5512234baefd"

