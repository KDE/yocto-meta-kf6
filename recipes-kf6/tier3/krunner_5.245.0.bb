# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/krunner-5.245.0.tar.xz"
SRC_URI[sha256sum] = "5187c30b9ee454ba76dad227cad69eff8fdefde4d53730350051525031f1523f"

