# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kdav-5.249.0.tar.xz"
SRC_URI[sha256sum] = "af09f48e11eea989733577353421bdfccbdff8059cb5af02a1812bd308274971"

