# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kded-6.2.0.tar.xz"
SRC_URI[sha256sum] = "ca6d6971b661b5142ede6ab9a1acbe24d4085efbc9f13988c179649b1261ab4f"

