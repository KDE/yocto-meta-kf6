# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kio-5.248.0.tar.xz"
SRC_URI[sha256sum] = "eecfc5d9f829847c3b955046955a2d3bcd8740e746fc6feeb4f0873ee57dc58e"

