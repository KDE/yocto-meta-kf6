# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/knotifyconfig-5.245.0.tar.xz"
SRC_URI[sha256sum] = "a1ecb772232a79a1b4356b93dce4f0d7434455a82856221ec194bc934d375123"

