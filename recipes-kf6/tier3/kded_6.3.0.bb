# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kded-6.3.0.tar.xz"
SRC_URI[sha256sum] = "d4b3e55cba11b6ba12df7a3ab958e637130499a34fcc3b918a1cab7de6235e48"

