# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/knotifyconfig-6.11.0.tar.xz"
SRC_URI[sha256sum] = "612511161758144a9d3d99d4f0a9eb75931c3f8af5966e045a088023ca1d0c6f"

