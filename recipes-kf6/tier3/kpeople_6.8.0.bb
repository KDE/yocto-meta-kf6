# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kpeople-6.8.0.tar.xz"
SRC_URI[sha256sum] = "d909b3c93964b6a9d2fc29f63fe004061adce4ef025dc6dcfded14a7a6bb9530"

