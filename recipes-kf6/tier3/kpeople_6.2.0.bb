# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/kpeople-6.2.0.tar.xz"
SRC_URI[sha256sum] = "3f5faa48ede1e47ee3e3747ef0adf2f1d8320dbefa8f0ec6eb75fd2f4ab45837"

