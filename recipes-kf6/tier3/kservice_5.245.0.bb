# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kservice-5.245.0.tar.xz"
SRC_URI[sha256sum] = "e3418443345600034e726cba8d86edc2801620e85c28a3d19b61ef45815e9d47"

