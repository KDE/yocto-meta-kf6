# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kdav-6.11.0.tar.xz"
SRC_URI[sha256sum] = "9ca5586e672f5643988dcd604b6a030f59b3d5e78f1cf3725f2e4f257852340e"

