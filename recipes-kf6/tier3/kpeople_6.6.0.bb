# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.6/kpeople-6.6.0.tar.xz"
SRC_URI[sha256sum] = "a0f100a325190859c7754f6a94c38d07ce60f89f30e0d58ddf99641f1f16e2b0"

