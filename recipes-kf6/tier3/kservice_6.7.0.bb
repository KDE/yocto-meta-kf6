# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kservice-6.7.0.tar.xz"
SRC_URI[sha256sum] = "39d2542e38fb3434c5405c92d5b45e0d5ba650d265309adf93c787a741d57fa1"

