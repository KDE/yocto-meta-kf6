# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.7/kparts-6.7.0.tar.xz"
SRC_URI[sha256sum] = "0b1b305050d61fcbefa7026b096dc6b47709d7435c69b18ab56a7e2ea57d759e"

