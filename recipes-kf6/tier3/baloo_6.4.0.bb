# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/baloo-6.4.0.tar.xz"
SRC_URI[sha256sum] = "07474aea2c407a4fb01cd2640589a93e8baadb04f8ba19ae6d8f40293c4c4699"

