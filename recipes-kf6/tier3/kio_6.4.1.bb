# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.4/kio-6.4.1.tar.xz"
SRC_URI[sha256sum] = "8bf1fc6c993510a16cd8f70779b023701f971471d369f565a8406f4b0d3b9059"

