# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/krunner-6.1.0.tar.xz"
SRC_URI[sha256sum] = "faa21f990d9886659ed44c753ccf8d77ceb07df94e84c01893f93b08e06760d4"

