# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/knewstuff-6.13.0.tar.xz"
SRC_URI[sha256sum] = "338873ceca0593f03a760732e4f8d0fd1bb059f21b7dedcde13f5e594226d798"

