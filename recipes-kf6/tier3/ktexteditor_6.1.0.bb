# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.1/ktexteditor-6.1.0.tar.xz"
SRC_URI[sha256sum] = "3ba18f41ef5e57fe868dc295d01852d31b1590c0be893ac97ceed9229b09a9df"

