# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kservice-5.248.0.tar.xz"
SRC_URI[sha256sum] = "26cb99e84806b1a61370453cdb70c91bbbae97dd6a6310709db093198d2d9cfa"

