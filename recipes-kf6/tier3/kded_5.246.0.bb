# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kded-5.246.0.tar.xz"
SRC_URI[sha256sum] = "15bad745e181da72aead03d18fde9aee7a287406a35a9b7b5d9d42368bba9657"

