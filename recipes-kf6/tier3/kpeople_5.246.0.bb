# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kpeople-5.246.0.tar.xz"
SRC_URI[sha256sum] = "38f1f918110369093ee8c72eff7d512931d479c9595dce20bfa7096a9e6d963a"

