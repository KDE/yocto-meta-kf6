# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.246.0/kio-5.246.0.tar.xz"
SRC_URI[sha256sum] = "9e377bb2dddef087220424285499e61f3b1766db587696d9479e069dd1e3d8ee"

