# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kcmutils-5.245.0.tar.xz"
SRC_URI[sha256sum] = "3fee72ff38cda25bdb5aae3cc9a5bde6b1063020fe410bed93e7bf1f73e89834"

