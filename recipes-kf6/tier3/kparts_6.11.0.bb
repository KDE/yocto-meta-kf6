# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kparts-6.11.0.tar.xz"
SRC_URI[sha256sum] = "3995f3556aba434de7b13dae099b51a0a86aeade60ba1e06592836d40669bb6a"

