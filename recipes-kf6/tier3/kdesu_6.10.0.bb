# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kdesu-6.10.0.tar.xz"
SRC_URI[sha256sum] = "5ab993abca85cb5798bb437b96a2b3d88079df86128ee30d66ee11f60e51c22e"

