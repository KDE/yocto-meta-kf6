# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.2/knewstuff-6.2.0.tar.xz"
SRC_URI[sha256sum] = "f54962756b8eb98c67840352a1efea4698f15a17d4bc8282f65adb0db08c5780"

