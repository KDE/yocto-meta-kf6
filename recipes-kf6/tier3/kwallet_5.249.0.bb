# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.249.0/kwallet-5.249.0.tar.xz"
SRC_URI[sha256sum] = "4ef45eb567dd43945dfa562da688817c6f917fcd63c3f779c77900ae0e22a646"

