# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.13/kwallet-6.13.0.tar.xz"
SRC_URI[sha256sum] = "1a6ff2ccf660a433bda6b00ac873796dcb46bd2443787fcf5fbe4c433ca8cb36"

