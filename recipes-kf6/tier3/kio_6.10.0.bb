# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.10/kio-6.10.0.tar.xz"
SRC_URI[sha256sum] = "7eb454438f149e7ed513c3bbd526b67e3e3ecfe32ae7c986168baa59600b699c"

