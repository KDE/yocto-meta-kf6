# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/knewstuff-6.8.0.tar.xz"
SRC_URI[sha256sum] = "36150509f9b7fa1ebc93515fc474601962af1e4712cbd45fb13610ae1bed44ca"

