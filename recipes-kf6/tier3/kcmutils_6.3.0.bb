# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kcmutils-6.3.0.tar.xz"
SRC_URI[sha256sum] = "9998b08ce423c9e59cdcc126a7475359a0c4fbe6b0400f44410c8a5cb6928e40"

