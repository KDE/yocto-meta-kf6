# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/purpose-5.245.0.tar.xz"
SRC_URI[sha256sum] = "93c32ac4bd7a356362397e8f9b062ffbd49c7803c8d94adeb032271aad29407e"

