# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.3/kio-6.3.0.tar.xz"
SRC_URI[sha256sum] = "39e1afb324069605609c60c1d4638da886debf6159179521167b5159d79a0448"

