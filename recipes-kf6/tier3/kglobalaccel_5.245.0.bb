# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.245.0/kglobalaccel-5.245.0.tar.xz"
SRC_URI[sha256sum] = "245b4fe0eb862dff81c662f46e318401fd441fde11de62cf2e1e0f135803fd26"

