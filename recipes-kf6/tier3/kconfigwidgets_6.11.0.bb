# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kconfigwidgets-6.11.0.tar.xz"
SRC_URI[sha256sum] = "28a1bb125161fe9ab0dbfa899433512e928669be31ce149fa25191a24a50242a"

