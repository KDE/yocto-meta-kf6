# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kbookmarks-6.8.0.tar.xz"
SRC_URI[sha256sum] = "0cbd215dd1bf2f7c305356d1362c3eb0585b0de9e195be125110f4b09fca5015"

