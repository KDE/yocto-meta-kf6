# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.11/kded-6.11.0.tar.xz"
SRC_URI[sha256sum] = "55c9921114299abd9bdc5e601ccc6a750ff2d331fc0836d79670ccbc508e06a4"

