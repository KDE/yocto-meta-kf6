# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/kdav-5.248.0.tar.xz"
SRC_URI[sha256sum] = "f67a81e3ee854fea87640bf7f019a8d4ea281f036fc9dcc5d0aa2c2f7d682a6d"

