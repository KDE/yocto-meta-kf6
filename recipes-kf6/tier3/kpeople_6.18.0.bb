# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.18/kpeople-6.18.0.tar.xz"
SRC_URI[sha256sum] = "09ba29efeb612eef4e54814f1f91e2d07c8942e6cf2c23176d9f306d68544d2b"

