# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/krunner-5.248.0.tar.xz"
SRC_URI[sha256sum] = "15d77f1333a7fefac315686b33a8191d2efa3d1ebcf71573957f1a6f4d32af7c"

