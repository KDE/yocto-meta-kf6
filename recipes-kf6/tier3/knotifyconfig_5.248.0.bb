# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/frameworks/5.248.0/knotifyconfig-5.248.0.tar.xz"
SRC_URI[sha256sum] = "dc0032a3726039cec039b44efed774c776b7a5223673f2f3eaaf80c720952862"

