# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.8/kcmutils-6.8.0.tar.xz"
SRC_URI[sha256sum] = "f8106c83ef85a1fc9b4185b81260048ebd8a64cdf05c8d0272ff83d6665cb1c0"

