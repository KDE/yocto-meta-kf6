# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.0/ktexteditor-6.0.0.tar.xz"
SRC_URI[sha256sum] = "620266c1d288d09f7aee4d2bc8b141c73555d5f033c452bcd2e2db2064b8fd42"

